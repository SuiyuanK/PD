X_M_cka.RF2YDec2to4a.I9_3.MXPA1 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXPA2 _CKA.RF2YDEC2TO4A.NET17[0]
+  _CKA.RF2YDEC2TO4A.IDEC[3] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka._clk.I222.MXNA1 _CKA._CLK.GTPRST _CKA.GTPA_SA VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_cka._clk.I222.MXPA1 _CKA._CLK.GTPRST _CKA.GTPA_SA VDDPE VNWP P11LL_CKT
+  W=0.71U L=0.04U
X_M_cka._clk.I5.MXNA1 _CKA._CLK.NRET RET VSSE VPW N11LL_CKT W=0.16U L=0.04U
X_M_cka._clk.I5.MXPA1 _CKA._CLK.NRET RET VDDPE VNWP P11LL_CKT W=0.155U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.I68.MXNA1 _CKA._CLK.SAE_DUMMY DBLA VSSE VPW
+  N11LL_CKT W=1.14U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.I68.MXPA1 _CKA._CLK.SAE_DUMMY DBLA VDDPE VNWP
+  P11LL_CKT W=2.265U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXN0 VSSE DBLA VSSE VPW N11LL_CKT W=2.39U L=0.085U
X_M_cka._clk._cdm2_dummy_hd.MXN1 VSS DBLA VSS VPW N11LL_CKT W=0.285U L=0.085U
X_M_cka._clk._cdm2_dummy_hd.MXN4_0 DBLA TIELODBLA DBLA VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXN4_1 DBLA TIELODBLA DBLA VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP1_0 DBLA TIELODBLA DBLA VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP1_1 DBLA TIELODBLA DBLA VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP2 VDDPE DBLA VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP3 VDDPE DBLA VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXPPU1_0 DBLA TIELODBLA DBLA VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXPPU1_1 DBLA TIELODBLA DBLA VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd.I61.MXNA1 _CKA._CLK.NET61 _CKA._CLK.SAE_DUMMY
+  VSSE VPW N11LL_CKT W=1.03U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd.I61.MXPA1 _CKA._CLK.NET61 _CKA._CLK.SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=1.53U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET40 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET045 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKMX1O _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET40 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET045 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET046 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKDLY2 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET046
+  VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET038 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKDLY2 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET046 _CKA._CLK.SAE_DUMMY
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK.SAE_DUMMY _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET046 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET038 _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK.SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I12.N1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXPA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 EMAA0 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0 VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXPA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 EMAA0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNA1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2 _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNB1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK.NET61 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPA1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPA2 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPB1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP _CKA._CLK.NET61 VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAA0 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAA0 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I19.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I19.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN _CKA._CLK.SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=0.45U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAA2 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAA2 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I20.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.NET67
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I20.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.NET67
+  VDDPE VNWP P11LL_CKT W=0.45U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I21.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VPW N11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I21.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I22.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VPW N11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I22.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I23.MXNA1 _CKA.GTPA_SA
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I23.MXPA1 _CKA.GTPA_SA
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I19.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I19.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN _CKA._CLK.SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAA1 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAA1 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I20.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I20.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I21.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I21.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I22.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I22.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I23.MXNA1 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I23.MXPA1 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_cka._clk._dwd.MXNA1 DWLA _CKA._CLK.NGTP VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_cka._clk._dwd.MXPA1 DWLA _CKA._CLK.NGTP VDDP_DWLA VNWP P11LL_CKT W=5.67U
+  L=0.04U
X_M_cka._clk._mem_gtp.I1.MXNA1 _CKA._CLK._MEM_GTP.C1 _CKA._CLK._MEM_GTP.NCLK
+  _CKA._CLK._MEM_GTP.I1.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXNA2 _CKA._CLK._MEM_GTP.I1.N1 _CKA._CLK.NRET VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXPA1 _CKA._CLK._MEM_GTP.C1 _CKA._CLK._MEM_GTP.NCLK
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXPA2 _CKA._CLK._MEM_GTP.C1 _CKA._CLK.NRET VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNA1 _CKA._CLK._MEM_GTP.C2 CENA
+  _CKA._CLK._MEM_GTP.I24.A1A2 VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNA2 _CKA._CLK._MEM_GTP.I24.A1A2
+  _CKA._CLK._MEM_GTP.NDFT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNB1 _CKA._CLK._MEM_GTP.C2 _CKA._CLK._MEM_GTP.C1
+  VSSE VPW N11LL_CKT W=0.24U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPA1 _CKA._CLK._MEM_GTP.C2 CENA
+  _CKA._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPA2 _CKA._CLK._MEM_GTP.C2 _CKA._CLK._MEM_GTP.NDFT
+  _CKA._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPB1 _CKA._CLK._MEM_GTP.I24.A1A2UP
+  _CKA._CLK._MEM_GTP.C1 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I6.MXNA1 GTPA _CKA._CLK.NGTP VSSE VPW N11LL_CKT W=5.61U
+  L=0.04U
X_M_cka._clk._mem_gtp.I6.MXPA1 GTPA _CKA._CLK.NGTP VDDPE VNWP P11LL_CKT
+  W=11.32U L=0.04U
X_M_cka._clk._mem_gtp.I68.MXNA1 _CKA._CLK._MEM_GTP.FEED _CKA._CLK.NGTP VSSE
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_cka._clk._mem_gtp.I68.MXPA1 _CKA._CLK._MEM_GTP.FEED _CKA._CLK.NGTP VDDPE
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_M_cka._clk._mem_gtp.I7.MXNA1 _CKA._CLK._MEM_GTP.NCLK CLKA VSS VPW N11LL_CKT
+  W=4.24U L=0.04U
X_M_cka._clk._mem_gtp.I7.MXPA1 _CKA._CLK._MEM_GTP.NCLK CLKA VDDPE VNWP
+  P11LL_CKT W=4.24U L=0.04U
X_M_cka._clk._mem_gtp.I74.MXNA1 _CKA._CLK.NFEED _CKA._CLK._MEM_GTP.FEED VSSE
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_cka._clk._mem_gtp.I74.MXPA1 _CKA._CLK.NFEED _CKA._CLK._MEM_GTP.FEED VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._mem_gtp.I82.MXNA1 _CKA._CLK._MEM_GTP.CTR _CKA._CLK._MEM_GTP.C3
+  VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_M_cka._clk._mem_gtp.I82.MXPA1 _CKA._CLK._MEM_GTP.CTR _CKA._CLK._MEM_GTP.C3
+  VDDPE VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXNA1 _CKA._CLK._MEM_GTP.C3 _CKA._CLK._MEM_GTP.C2
+  _CKA._CLK._MEM_GTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXNA2 _CKA._CLK._MEM_GTP.I83.N1 _CKA._CLK.NFEED VSSE
+  VPW N11LL_CKT W=0.71U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXPA1 _CKA._CLK._MEM_GTP.C3 _CKA._CLK._MEM_GTP.C2
+  VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXPA2 _CKA._CLK._MEM_GTP.C3 _CKA._CLK.NFEED VDDPE
+  VNWP P11LL_CKT W=0.36U L=0.04U
X_M_cka._clk._mem_gtp.I86.MXNA1 _CKA._CLK._MEM_GTP.NDFT DFTRAMBYPA VSS VPW
+  N11LL_CKT W=0.21U L=0.04U
X_M_cka._clk._mem_gtp.I86.MXPA1 _CKA._CLK._MEM_GTP.NDFT DFTRAMBYPA VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.MXN0 _CKA._CLK._MEM_GTP.NCLK _CKA._CLK._MEM_GTP.CTR
+  _CKA._CLK.NGTP VPW N11LL_CKT W=4.26U L=0.04U
X_M_cka._clk._mem_gtp.MXN7 _CKA._CLK.NGTP _CKA._CLK._MEM_GTP.FEED
+  _CKA._CLK._MEM_GTP.NET114 VPW N11LL_CKT W=0.26U L=0.04U
X_M_cka._clk._mem_gtp.MXN8 _CKA._CLK._MEM_GTP.NET114 _CKA._CLK.GTPRST VSSE VPW
+  N11LL_CKT W=0.26U L=0.04U
X_M_cka._clk._mem_gtp.MXP1 _CKA._CLK.NGTP _CKA._CLK.GTPRST VDDPE VNWP
+  P11LL_CKT W=4.26U L=0.04U
X_M_cka._clk._mem_gtp.MXP2 _CKA._CLK._MEM_GTP.NET127 _CKA._CLK._MEM_GTP.CTR
+  VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cka._clk._mem_gtp.MXP3 _CKA._CLK._MEM_GTP.NET127 CLKA VDDPE VNWP P11LL_CKT
+  W=0.48U L=0.04U
X_M_cka._clk._mem_gtp.MXP5 _CKA._CLK.NGTP _CKA._CLK._MEM_GTP.FEED
+  _CKA._CLK._MEM_GTP.NET127 VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cka._ctl_prechbl.I29.MXNA1 PRECHA_L _CKA._CTL_PRECHBL.NBLPRECH_L VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_cka._ctl_prechbl.I29.MXPA1 PRECHA_L _CKA._CTL_PRECHBL.NBLPRECH_L VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_cka._ctl_prechbl.I36.MXNA1 PRECHA_R _CKA._CTL_PRECHBL.NBLPRECH_R VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_cka._ctl_prechbl.I36.MXPA1 PRECHA_R _CKA._CTL_PRECHBL.NBLPRECH_R VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_cka._ctl_prechbl.I37.MXNA1 _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.NET0130 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I37.MXPA1 _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.NET0130 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I51.MXNA1 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I51.MXNA2 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.DRET
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I51.MXPA1 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.I51.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I51.MXPA2 _CKA._CTL_PRECHBL.I51.P1 _CKA._CTL_PRECHBL.DRET
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I52.MXNA1 _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I52.MXNA2 _CKA._CTL_PRECHBL.DGTP_R DFTRETA VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I52.MXPA1 _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.I52.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I52.MXPA2 _CKA._CTL_PRECHBL.I52.P1 DFTRETA VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I64.MXNA1 _CKA._CTL_PRECHBL.I64.N1
+  _CKA._CTL_PRECHBL.NET039 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I64.MXNOE _CKA._CTL_PRECHBL.NET047
+  _CKA._CTL_PRECHBL.NET039 _CKA._CTL_PRECHBL.I64.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka._ctl_prechbl.I64.MXPA1 _CKA._CTL_PRECHBL.I64.P1
+  _CKA._CTL_PRECHBL.NET039 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I64.MXPOEN _CKA._CTL_PRECHBL.NET047
+  _CKA._CTL_PRECHBL.NET039 _CKA._CTL_PRECHBL.I64.P1 VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._ctl_prechbl.I65.MXNA1 _CKA._CTL_PRECHBL.I65.N1 DFTRETA VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I65.MXNOE _CKA._CTL_PRECHBL.NET039 DFTRETA
+  _CKA._CTL_PRECHBL.I65.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I65.MXPA1 _CKA._CTL_PRECHBL.I65.P1 DFTRETA VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I65.MXPOEN _CKA._CTL_PRECHBL.NET039 DFTRETA
+  _CKA._CTL_PRECHBL.I65.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I68.MXNA1 _CKA._CTL_PRECHBL.DRET _CKA._CTL_PRECHBL.NET49
+  VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_cka._ctl_prechbl.I68.MXPA1 _CKA._CTL_PRECHBL.DRET _CKA._CTL_PRECHBL.NET49
+  VDDPE VNWP P11LL_CKT W=0.34U L=0.04U
X_M_cka._ctl_prechbl.I69.MXNA1 _CKA._CTL_PRECHBL.NET49 DFTRETA VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXNA2 _CKA._CTL_PRECHBL.NET49
+  _CKA._CTL_PRECHBL.NET047 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXPA1 _CKA._CTL_PRECHBL.NET49 DFTRETA
+  _CKA._CTL_PRECHBL.I69.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXPA2 _CKA._CTL_PRECHBL.I69.P1
+  _CKA._CTL_PRECHBL.NET047 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNA1 _CKA._CTL_PRECHBL.NBLPRECH_R _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I72.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNA2 _CKA._CTL_PRECHBL.I72.A1A2
+  _CKA._CTL_PRECHBL.DGTP_R VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNB1 _CKA._CTL_PRECHBL.NBLPRECH_R MOD_RDT_P2 VSSE
+  VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXPA1 _CKA._CTL_PRECHBL.NBLPRECH_R _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_cka._ctl_prechbl.I72.MXPA2 _CKA._CTL_PRECHBL.NBLPRECH_R
+  _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_cka._ctl_prechbl.I72.MXPB1 _CKA._CTL_PRECHBL.I72.A1A2UP MOD_RDT_P2 VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNA1 _CKA._CTL_PRECHBL.NBLPRECH_L _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I73.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNA2 _CKA._CTL_PRECHBL.I73.A1A2
+  _CKA._CTL_PRECHBL.DGTP_L VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNB1 _CKA._CTL_PRECHBL.NBLPRECH_L MOD_RDT_P2 VSSE
+  VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXPA1 _CKA._CTL_PRECHBL.NBLPRECH_L _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_cka._ctl_prechbl.I73.MXPA2 _CKA._CTL_PRECHBL.NBLPRECH_L
+  _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_cka._ctl_prechbl.I73.MXPB1 _CKA._CTL_PRECHBL.I73.A1A2UP MOD_RDT_P2 VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._ctl_prechbl.I75.MXNA1 _CKA._CTL_PRECHBL.NET0130
+  _CKA._CTL_PRECHBL.NET0124 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I75.MXPA1 _CKA._CTL_PRECHBL.NET0130
+  _CKA._CTL_PRECHBL.NET0124 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I76.MXNA1 _CKA._CTL_PRECHBL.NET0124 _CKA.NGTPA VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I76.MXPA1 _CKA._CTL_PRECHBL.NET0124 _CKA.NGTPA VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_cka._mem_tiehilo.MXN0 TIELODBLA _CKA._MEM_TIEHILO.NODEB VSSE VPW N11LL_CKT
+  W=1.42U L=0.04U
X_M_cka._mem_tiehilo.MXN1 _CKA._MEM_TIEHILO.NODEA _CKA._MEM_TIEHILO.NODEA VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_cka._mem_tiehilo.MXN2 _CKA._MEM_TIEHILO.NODEA _CKA._MEM_TIEHILO.NODEB VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_cka._mem_tiehilo.MXP1 _CKA._MEM_TIEHILO.NODEB _CKA._MEM_TIEHILO.NODEA
+  VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_M_cka._mem_tiehilo.MXP4 TIEHIA _CKA._MEM_TIEHILO.NODEA VDDPE VNWP P11LL_CKT
+  W=2.04U L=0.04U
X_M_cka._rdt_p2latch.I47.MXNA1 _CKA._RDT_P2LATCH.ND RDT
+  _CKA._RDT_P2LATCH.I47.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXNA2 _CKA._RDT_P2LATCH.I47.N1 _CKA.NDFTNRETA VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXPA1 _CKA._RDT_P2LATCH.ND RDT VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXPA2 _CKA._RDT_P2LATCH.ND _CKA.NDFTNRETA VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I48.MXNOE _CKA.NET258 NCLKA _CKA._RDT_P2LATCH.ND VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._rdt_p2latch.I48.MXPOEN _CKA.NET258 BCLKA _CKA._RDT_P2LATCH.ND VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._rdt_p2latch.I50.MXNA1 MOD_RDT_P2 _CKA.NET258 VSSE VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_cka._rdt_p2latch.I50.MXPA1 MOD_RDT_P2 _CKA.NET258 VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_cka._rdt_p2latch.I55.MXNA1 _CKA._RDT_P2LATCH.I55.N1 MOD_RDT_P2 VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXNOE _CKA.NET258 BCLKA _CKA._RDT_P2LATCH.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXPA1 _CKA._RDT_P2LATCH.I55.P1 MOD_RDT_P2 VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXPOEN _CKA.NET258 NCLKA _CKA._RDT_P2LATCH.I55.P1
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_ckb.I239_0.MXNA1 _CKB.INCAB_P2[0] _CKB.ICAB_P2[0] VSS VPW N11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I239_0.MXPA1 _CKB.INCAB_P2[0] _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb.I239_1.MXNA1 _CKB.INCAB_P2[1] _CKB.ICAB_P2[1] VSS VPW N11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I239_1.MXPA1 _CKB.INCAB_P2[1] _CKB.ICAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb.I248.MXNA1 WCLK _CKB.NET0153 VSS VPW N11LL_CKT W=2.27U L=0.04U
X_M_ckb.I248.MXPA1 WCLK _CKB.NET0153 VDDPE VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckb.I249.MXNA1 _CKB.NET0153 GTPB VSS VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb.I249.MXNA2 _CKB.NET0153 _CKB.NET0125 VSS VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb.I249.MXPA1 _CKB.NET0153 GTPB _CKB.I249.P1 VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb.I249.MXPA2 _CKB.I249.P1 _CKB.NET0125 VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb.I251.MXNA1 _CKB.DFTCLKB NCLKB VSSE VPW N11LL_CKT W=1.5U L=0.04U
X_M_ckb.I251.MXNA2 _CKB.DFTCLKB DFTRAMBYPB VSSE VPW N11LL_CKT W=1.02U L=0.04U
X_M_ckb.I251.MXP0 _CKB.DFTCLKB NCLKB _CKB.I251.P2 VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I251.MXP1 _CKB.I251.P2 DFTRAMBYPB VDDPE VNWP P11LL_CKT W=1.66U L=0.04U
X_M_ckb.I251.MXPA1 _CKB.DFTCLKB NCLKB _CKB.I251.P1 VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I251.MXPA2 _CKB.I251.P1 DFTRAMBYPB VDDPE VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I253.MXNA1 _CKB.FORCERDBL NFORCERDBL VSSE VPW N11LL_CKT W=2U L=0.04U
X_M_ckb.I253.MXPA1 _CKB.FORCERDBL NFORCERDBL VDDPE VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I256_0.MXNA1 _CKB.ICAB_P2[0] _CKB.NET0128[1] VSS VPW N11LL_CKT W=0.33U
+  L=0.04U
X_M_ckb.I256_0.MXPA1 _CKB.ICAB_P2[0] _CKB.NET0128[1] VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb.I256_1.MXNA1 _CKB.ICAB_P2[1] _CKB.NET0128[0] VSS VPW N11LL_CKT W=0.33U
+  L=0.04U
X_M_ckb.I256_1.MXPA1 _CKB.ICAB_P2[1] _CKB.NET0128[0] VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb.I257_0.MXNA1 _CKB.NCAB_P2[0] CAB_P2[0] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_ckb.I257_0.MXPA1 _CKB.NCAB_P2[0] CAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb.I257_1.MXNA1 _CKB.NCAB_P2[1] CAB_P2[1] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_ckb.I257_1.MXPA1 _CKB.NCAB_P2[1] CAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb.I260.MXN3 _CKB.I260.NET057 _CKB.I260.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I260.MXN4 _CKB.I260.NDI _CKB.NET061 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I260.MXN8 _CKB.NET0125 _CKB.I260.NDI _CKB.I260.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I260.MXP0 _CKB.NET0125 _CKB.I260.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I260.MXP1 _CKB.I260.NDI _CKB.NET061 _CKB.I260.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I260.MXP2 _CKB.I260.NET044 _CKB.NET061 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I261_0.MXNA1 _CKB.BCAB_P2[0] _CKB.NCAB_P2[0] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I261_0.MXPA1 _CKB.BCAB_P2[0] _CKB.NCAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_ckb.I261_1.MXNA1 _CKB.BCAB_P2[1] _CKB.NCAB_P2[1] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I261_1.MXPA1 _CKB.BCAB_P2[1] _CKB.NCAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_ckb.I262_0.MXNA1 _CKB.NET0128[1] _CKB.BCAB_P2[0] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I262_0.MXPA1 _CKB.NET0128[1] _CKB.BCAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I262_1.MXNA1 _CKB.NET0128[0] _CKB.BCAB_P2[1] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I262_1.MXPA1 _CKB.NET0128[0] _CKB.BCAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I264.MXN3 _CKB.I264.NET057 _CKB.I264.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXN4 _CKB.I264.NDI GTPB VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I264.MXN8 _CKB.NET061 _CKB.I264.NDI _CKB.I264.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I264.MXP0 _CKB.NET061 _CKB.I264.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXP1 _CKB.I264.NDI GTPB _CKB.I264.NET044 VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXP2 _CKB.I264.NET044 GTPB VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb.I276.MXN3 _CKB.I276.NET057 _CKB.I276.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXN4 _CKB.I276.NDI _CKB.NET0125 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXN8 _CKB.NET062 _CKB.I276.NDI _CKB.I276.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I276.MXP0 _CKB.NET062 _CKB.I276.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXP1 _CKB.I276.NDI _CKB.NET0125 _CKB.I276.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I276.MXP2 _CKB.I276.NET044 _CKB.NET0125 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXN3 _CKB.I277.NET057 _CKB.I277.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXN4 _CKB.I277.NDI _CKB.NET062 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I277.MXN8 _CKB.NET071 _CKB.I277.NDI _CKB.I277.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I277.MXP0 _CKB.NET071 _CKB.I277.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXP1 _CKB.I277.NDI _CKB.NET062 _CKB.I277.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I277.MXP2 _CKB.I277.NET044 _CKB.NET062 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I32.MXNA1 NCLKB GTPB VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.I32.MXPA1 NCLKB GTPB VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_ckb.I4.MXNA1 _CKB.NICLK GTPB VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb.I4.MXPA1 _CKB.NICLK GTPB VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_M_ckb.I5.MXNA1 BCLKB _CKB.NICLK VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.I5.MXPA1 BCLKB _CKB.NICLK VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_ckb.I51.MXNA1 _CKB.NGTPB GTPB VSS VPW N11LL_CKT W=0.91U L=0.04U
X_M_ckb.I51.MXPA1 _CKB.NGTPB GTPB VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckb.MXN0 TIELOCDB TIEHIB VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb.MXN1 TIELOFPB TIEHIB VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[0] _CKB.ICAB_P2[1]
+  _CKB.RF2YDEC2TO4_COL.I0_0.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXP1 _CKB.RF2YDEC2TO4_COL.I0_0.P2 _CKB.ICAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_0.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_0.P1
+  _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.ICAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.INCAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[1] _CKB.ICAB_P2[1]
+  _CKB.RF2YDEC2TO4_COL.I0_1.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXP1 _CKB.RF2YDEC2TO4_COL.I0_1.P2
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.ICAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_1.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_1.P1
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.ICAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_2.P2 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXP1 _CKB.RF2YDEC2TO4_COL.I0_2.P2 _CKB.ICAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_2.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_2.P1
+  _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_3.P2 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXP1 _CKB.RF2YDEC2TO4_COL.I0_3.P2
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_3.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_3.P1
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[3] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_0.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXN1 _CKB.RF2YDEC2TO4_COL.I1_0.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_0.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_0.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[2] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_1.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXN1 _CKB.RF2YDEC2TO4_COL.I1_1.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_1.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_1.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[1] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_2.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXN1 _CKB.RF2YDEC2TO4_COL.I1_2.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_2.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_2.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[0] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_3.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXN1 _CKB.RF2YDEC2TO4_COL.I1_3.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_3.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_3.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_0.MXNA1 YPCOL[0] _CKB.RF2YDEC2TO4_COL.NET17[3]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_0.MXPA1 YPCOL[0] _CKB.RF2YDEC2TO4_COL.NET17[3]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_1.MXNA1 YPCOL[1] _CKB.RF2YDEC2TO4_COL.NET17[2]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_1.MXPA1 YPCOL[1] _CKB.RF2YDEC2TO4_COL.NET17[2]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_2.MXNA1 YPCOL[2] _CKB.RF2YDEC2TO4_COL.NET17[1]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_2.MXPA1 YPCOL[2] _CKB.RF2YDEC2TO4_COL.NET17[1]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_3.MXNA1 YPCOL[3] _CKB.RF2YDEC2TO4_COL.NET17[0]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_3.MXPA1 YPCOL[3] _CKB.RF2YDEC2TO4_COL.NET17[0]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_0.MXNA1 YPBCLK[0] _CKB.RF2YDEC2TO4B.NET24[3] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_0.MXPA1 YPBCLK[0] _CKB.RF2YDEC2TO4B.NET24[3] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_1.MXNA1 YPBCLK[1] _CKB.RF2YDEC2TO4B.NET24[2] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_1.MXPA1 YPBCLK[1] _CKB.RF2YDEC2TO4B.NET24[2] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_2.MXNA1 YPBCLK[2] _CKB.RF2YDEC2TO4B.NET24[1] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_2.MXPA1 YPBCLK[2] _CKB.RF2YDEC2TO4B.NET24[1] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_3.MXNA1 YPBCLK[3] _CKB.RF2YDEC2TO4B.NET24[0] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_3.MXPA1 YPBCLK[3] _CKB.RF2YDEC2TO4B.NET24[0] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXN0 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_0.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXN1 _CKB.RF2YDEC2TO4B.I6_0.N2
+  _CKB.RF2YDEC2TO4B.IDEC[0] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXNA1 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_0.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXNA2 _CKB.RF2YDEC2TO4B.I6_0.N1
+  _CKB.RF2YDEC2TO4B.IDEC[0] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXPA1 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXPA2 _CKB.RF2YDEC2TO4B.NET24[3]
+  _CKB.RF2YDEC2TO4B.IDEC[0] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXN0 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_1.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXN1 _CKB.RF2YDEC2TO4B.I6_1.N2
+  _CKB.RF2YDEC2TO4B.IDEC[1] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXNA1 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_1.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXNA2 _CKB.RF2YDEC2TO4B.I6_1.N1
+  _CKB.RF2YDEC2TO4B.IDEC[1] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXPA1 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXPA2 _CKB.RF2YDEC2TO4B.NET24[2]
+  _CKB.RF2YDEC2TO4B.IDEC[1] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXN0 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_2.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXN1 _CKB.RF2YDEC2TO4B.I6_2.N2
+  _CKB.RF2YDEC2TO4B.IDEC[2] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXNA1 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_2.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXNA2 _CKB.RF2YDEC2TO4B.I6_2.N1
+  _CKB.RF2YDEC2TO4B.IDEC[2] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXPA1 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXPA2 _CKB.RF2YDEC2TO4B.NET24[1]
+  _CKB.RF2YDEC2TO4B.IDEC[2] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXN0 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_3.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXN1 _CKB.RF2YDEC2TO4B.I6_3.N2
+  _CKB.RF2YDEC2TO4B.IDEC[3] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXNA1 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_3.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXNA2 _CKB.RF2YDEC2TO4B.I6_3.N1
+  _CKB.RF2YDEC2TO4B.IDEC[3] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXPA1 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXPA2 _CKB.RF2YDEC2TO4B.NET24[0]
+  _CKB.RF2YDEC2TO4B.IDEC[3] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXP0 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_0.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXP1 _CKB.RF2YDEC2TO4B.I7_0.P2 _CKB.BCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_0.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXPA2 _CKB.RF2YDEC2TO4B.I7_0.P1 _CKB.BCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.NCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXP0 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_1.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXP1 _CKB.RF2YDEC2TO4B.I7_1.P2 _CKB.NCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_1.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXPA2 _CKB.RF2YDEC2TO4B.I7_1.P1 _CKB.NCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.BCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXP0 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_2.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXP1 _CKB.RF2YDEC2TO4B.I7_2.P2 _CKB.BCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_2.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXPA2 _CKB.RF2YDEC2TO4B.I7_2.P1 _CKB.BCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXP0 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_3.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXP1 _CKB.RF2YDEC2TO4B.I7_3.P2 _CKB.NCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_3.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXPA2 _CKB.RF2YDEC2TO4B.I7_3.P1 _CKB.NCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb._clk.I222.MXNA1 _CKB._CLK.GTPRST _CKB.NET217 VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk.I222.MXPA1 _CKB._CLK.GTPRST _CKB.NET217 VDDPE VNWP P11LL_CKT
+  W=0.71U L=0.04U
X_M_ckb._clk.I5.MXNA1 _CKB._CLK.NRET RET VSSE VPW N11LL_CKT W=0.16U L=0.04U
X_M_ckb._clk.I5.MXPA1 _CKB._CLK.NRET RET VDDPE VNWP P11LL_CKT W=0.155U L=0.04U
X_M_ckb._clk.I6.MXN11 _CKB._CLK.I6.NET050 _CKB._CLK.I6.DI1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN12 _CKB._CLK.I6.NDI1 SAE_DUMMY _CKB._CLK.I6.NET050 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN13 _CKB._CLK.SAE_DUMMY_OUT _CKB._CLK.I6.NDI1 VSSE VPW
+  N11LL_CKT W=0.565U L=0.04U
X_M_ckb._clk.I6.MXN3 _CKB._CLK.I6.NET057 SAEDIN VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_ckb._clk.I6.MXN4 _CKB._CLK.I6.DI1 _CKB._CLK.I6.NDI VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN8 _CKB._CLK.I6.NDI SAEDIN _CKB._CLK.I6.NET057 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXP0 _CKB._CLK.I6.NDI SAEDIN VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I6.MXP1 _CKB._CLK.I6.DI1 _CKB._CLK.I6.NDI _CKB._CLK.I6.NET044
+  VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP2 _CKB._CLK.I6.NET044 _CKB._CLK.I6.NDI VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP3 _CKB._CLK.I6.NDI1 _CKB._CLK.I6.DI1 VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP5 _CKB._CLK.SAE_DUMMY_OUT _CKB._CLK.I6.NDI1 VDDPE VNWP
+  P11LL_CKT W=0.735U L=0.04U
X_M_ckb._clk.I6.MXP6 _CKB._CLK.I6.NDI1 SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXN15 _CKB._CLK.I7.NDI0 SAEDO0 VSSE VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_ckb._clk.I7.MXN16 _CKB._CLK.I7.NET042 _CKB._CLK.I7.NDI0 VSSE VPW N11LL_CKT
+  W=0.255U L=0.04U
X_M_ckb._clk.I7.MXN4 SAEDO1 _CKB._CLK.I7.NDI VSSE VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_ckb._clk.I7.MXN8 _CKB._CLK.I7.NDI _CKB._CLK.I7.NET042 VSSE VPW N11LL_CKT
+  W=0.255U L=0.04U
X_M_ckb._clk.I7.MXP0 _CKB._CLK.I7.NDI _CKB._CLK.I7.NET042 VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I7.MXP1 SAEDO1 _CKB._CLK.I7.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXP8 _CKB._CLK.I7.NDI0 SAEDO0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXP9 _CKB._CLK.I7.NET042 _CKB._CLK.I7.NDI0 VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.I68.MXNA1 ISAE_DUM0 DBLB VSSE VPW N11LL_CKT
+  W=1.14U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.I68.MXPA1 ISAE_DUM0 DBLB VDDPE VNWP P11LL_CKT
+  W=2.265U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXN0 VSSE DBLB VSSE VPW N11LL_CKT W=2.39U L=0.085U
X_M_ckb._clk._cdm2_dummy_hd.MXN1 VSS DBLB VSS VPW N11LL_CKT W=0.285U L=0.085U
X_M_ckb._clk._cdm2_dummy_hd.MXN4_0 DBLB TIELODBLB DBLB VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXN4_1 DBLB TIELODBLB DBLB VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP1_0 DBLB TIELODBLB DBLB VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP1_1 DBLB TIELODBLB DBLB VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP2 VDDPE DBLB VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP3 VDDPE DBLB VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXPPU1_0 DBLB TIELODBLB DBLB VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXPPU1_1 DBLB TIELODBLB DBLB VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd.I61.MXNA1 _CKB._CLK.NET101 SAE_DUMMY VSSE VPW
+  N11LL_CKT W=1.03U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd.I61.MXPA1 _CKB._CLK.NET101 SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET40 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET045 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKMX1O _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET40 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET045 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET046 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKDLY2 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET046
+  VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET038 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKDLY2 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET046 SAE_DUMMY
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  SAE_DUMMY _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET046 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET038 SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I12.N1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXPA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 EMAB0 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0 VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXPA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 EMAB0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNA1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2 _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNB1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK.NET101 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPA1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPA2 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP _CKB._CLK.NET101 VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAB0 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAB0 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I19.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I19.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN SAE_DUMMY VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAB2 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAB2 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I20.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.NET67
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I20.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.NET67
+  VDDPE VNWP P11LL_CKT W=0.45U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I21.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VPW N11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I21.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAB2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VNWP P11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I22.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAB2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VPW N11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I22.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VNWP P11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I23.MXNA1 _CKB.NET217
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I23.MXPA1 _CKB.NET217
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I19.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I19.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN SAE_DUMMY VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAB1 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAB1 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I20.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I20.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I21.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I21.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I22.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I22.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I23.MXNA1 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I23.MXPA1 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_ckb._clk._dwd.MXNA1 DWLB _CKB._CLK.NGTP VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb._clk._dwd.MXPA1 DWLB _CKB._CLK.NGTP VDDP_DWLB VNWP P11LL_CKT W=5.67U
+  L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXNA1 _CKB._CLK._MEM_GTP.C1 _CKB._CLK._MEM_GTP.NCLK
+  _CKB._CLK._MEM_GTP.I1.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXNA2 _CKB._CLK._MEM_GTP.I1.N1 _CKB._CLK.NRET VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXPA1 _CKB._CLK._MEM_GTP.C1 _CKB._CLK._MEM_GTP.NCLK
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXPA2 _CKB._CLK._MEM_GTP.C1 _CKB._CLK.NRET VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNA1 _CKB._CLK._MEM_GTP.C2 CENB
+  _CKB._CLK._MEM_GTP.I24.A1A2 VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNA2 _CKB._CLK._MEM_GTP.I24.A1A2
+  _CKB._CLK._MEM_GTP.NDFT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNB1 _CKB._CLK._MEM_GTP.C2 _CKB._CLK._MEM_GTP.C1
+  VSSE VPW N11LL_CKT W=0.24U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPA1 _CKB._CLK._MEM_GTP.C2 CENB
+  _CKB._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPA2 _CKB._CLK._MEM_GTP.C2 _CKB._CLK._MEM_GTP.NDFT
+  _CKB._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPB1 _CKB._CLK._MEM_GTP.I24.A1A2UP
+  _CKB._CLK._MEM_GTP.C1 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I6.MXNA1 GTPB _CKB._CLK.NGTP VSSE VPW N11LL_CKT W=5.61U
+  L=0.04U
X_M_ckb._clk._mem_gtp.I6.MXPA1 GTPB _CKB._CLK.NGTP VDDPE VNWP P11LL_CKT
+  W=11.32U L=0.04U
X_M_ckb._clk._mem_gtp.I68.MXNA1 _CKB._CLK._MEM_GTP.FEED _CKB._CLK.NGTP VSSE
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_ckb._clk._mem_gtp.I68.MXPA1 _CKB._CLK._MEM_GTP.FEED _CKB._CLK.NGTP VDDPE
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_M_ckb._clk._mem_gtp.I7.MXNA1 _CKB._CLK._MEM_GTP.NCLK CLKB VSS VPW N11LL_CKT
+  W=4.24U L=0.04U
X_M_ckb._clk._mem_gtp.I7.MXPA1 _CKB._CLK._MEM_GTP.NCLK CLKB VDDPE VNWP
+  P11LL_CKT W=4.24U L=0.04U
X_M_ckb._clk._mem_gtp.I74.MXNA1 _CKB._CLK.NFEED _CKB._CLK._MEM_GTP.FEED VSSE
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb._clk._mem_gtp.I74.MXPA1 _CKB._CLK.NFEED _CKB._CLK._MEM_GTP.FEED VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._mem_gtp.I82.MXNA1 _CKB._CLK._MEM_GTP.CTR _CKB._CLK._MEM_GTP.C3
+  VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_M_ckb._clk._mem_gtp.I82.MXPA1 _CKB._CLK._MEM_GTP.CTR _CKB._CLK._MEM_GTP.C3
+  VDDPE VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXNA1 _CKB._CLK._MEM_GTP.C3 _CKB._CLK._MEM_GTP.C2
+  _CKB._CLK._MEM_GTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXNA2 _CKB._CLK._MEM_GTP.I83.N1 _CKB._CLK.NFEED VSSE
+  VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXPA1 _CKB._CLK._MEM_GTP.C3 _CKB._CLK._MEM_GTP.C2
+  VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXPA2 _CKB._CLK._MEM_GTP.C3 _CKB._CLK.NFEED VDDPE
+  VNWP P11LL_CKT W=0.36U L=0.04U
X_M_ckb._clk._mem_gtp.I86.MXNA1 _CKB._CLK._MEM_GTP.NDFT DFTRAMBYPB VSS VPW
+  N11LL_CKT W=0.21U L=0.04U
X_M_ckb._clk._mem_gtp.I86.MXPA1 _CKB._CLK._MEM_GTP.NDFT DFTRAMBYPB VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.MXN0 _CKB._CLK._MEM_GTP.NCLK _CKB._CLK._MEM_GTP.CTR
+  _CKB._CLK.NGTP VPW N11LL_CKT W=4.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXN7 _CKB._CLK.NGTP _CKB._CLK._MEM_GTP.FEED
+  _CKB._CLK._MEM_GTP.NET114 VPW N11LL_CKT W=0.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXN8 _CKB._CLK._MEM_GTP.NET114 _CKB._CLK.GTPRST VSSE VPW
+  N11LL_CKT W=0.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXP1 _CKB._CLK.NGTP _CKB._CLK.GTPRST VDDPE VNWP
+  P11LL_CKT W=4.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXP2 _CKB._CLK._MEM_GTP.NET127 _CKB._CLK._MEM_GTP.CTR
+  VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckb._clk._mem_gtp.MXP3 _CKB._CLK._MEM_GTP.NET127 CLKB VDDPE VNWP P11LL_CKT
+  W=0.48U L=0.04U
X_M_ckb._clk._mem_gtp.MXP5 _CKB._CLK.NGTP _CKB._CLK._MEM_GTP.FEED
+  _CKB._CLK._MEM_GTP.NET127 VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckb._clk._stpdly0.MXN0 _CKB._CLK._STPDLY0.NDI ISAE_DUM0
+  _CKB._CLK._STPDLY0.NET37 VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckb._clk._stpdly0.MXN3 _CKB._CLK._STPDLY0.NET37 ISAE_DUM0 VSSE VPW
+  N11LL_CKT W=0.2U L=0.04U
X_M_ckb._clk._stpdly0.MXN4 ISAE_DUM1 _CKB._CLK._STPDLY0.NDI VSSE VPW N11LL_CKT
+  W=0.62U L=0.04U
X_M_ckb._clk._stpdly0.MXP0 _CKB._CLK._STPDLY0.NDI ISAE_DUM0 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly0.MXP1 ISAE_DUM1 _CKB._CLK._STPDLY0.NDI VDDPE VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_ckb._clk._stpdly1.MXN3 VSSE ISAE_DUM1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXN4 SAEDO0 _CKB._CLK._STPDLY1.NDI VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXN8 _CKB._CLK._STPDLY1.NDI ISAE_DUM1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXP0 _CKB._CLK._STPDLY1.NDI ISAE_DUM1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXP1 SAEDO0 _CKB._CLK._STPDLY1.NDI VDDPE VNWP P11LL_CKT
+  W=0.183U L=0.04U
X_M_ckb._clk._stpdly1.MXP2 SAEDO0 _CKB._CLK._STPDLY1.NDI VDDPE VNWP P11LL_CKT
+  W=0.183U L=0.04U
X_M_ckb._ctl_prechbl.I29.MXNA1 PRECHB_L _CKB._CTL_PRECHBL.NBLPRECH_L VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_ckb._ctl_prechbl.I29.MXPA1 PRECHB_L _CKB._CTL_PRECHBL.NBLPRECH_L VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_ckb._ctl_prechbl.I36.MXNA1 PRECHB_R _CKB._CTL_PRECHBL.NBLPRECH_R VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_ckb._ctl_prechbl.I36.MXPA1 PRECHB_R _CKB._CTL_PRECHBL.NBLPRECH_R VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_ckb._ctl_prechbl.I37.MXNA1 _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.NET0130 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I37.MXPA1 _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.NET0130 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXNA1 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXNA2 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.DRET
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXPA1 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.I51.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXPA2 _CKB._CTL_PRECHBL.I51.P1 _CKB._CTL_PRECHBL.DRET
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXNA1 _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXNA2 _CKB._CTL_PRECHBL.DGTP_R DFTRETB VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXPA1 _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.I52.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXPA2 _CKB._CTL_PRECHBL.I52.P1 DFTRETB VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXNA1 _CKB._CTL_PRECHBL.I64.N1
+  _CKB._CTL_PRECHBL.NET039 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXNOE _CKB._CTL_PRECHBL.NET047
+  _CKB._CTL_PRECHBL.NET039 _CKB._CTL_PRECHBL.I64.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._ctl_prechbl.I64.MXPA1 _CKB._CTL_PRECHBL.I64.P1
+  _CKB._CTL_PRECHBL.NET039 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXPOEN _CKB._CTL_PRECHBL.NET047
+  _CKB._CTL_PRECHBL.NET039 _CKB._CTL_PRECHBL.I64.P1 VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._ctl_prechbl.I65.MXNA1 _CKB._CTL_PRECHBL.I65.N1 DFTRETB VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXNOE _CKB._CTL_PRECHBL.NET039 DFTRETB
+  _CKB._CTL_PRECHBL.I65.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXPA1 _CKB._CTL_PRECHBL.I65.P1 DFTRETB VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXPOEN _CKB._CTL_PRECHBL.NET039 DFTRETB
+  _CKB._CTL_PRECHBL.I65.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I68.MXNA1 _CKB._CTL_PRECHBL.DRET _CKB._CTL_PRECHBL.NET49
+  VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_ckb._ctl_prechbl.I68.MXPA1 _CKB._CTL_PRECHBL.DRET _CKB._CTL_PRECHBL.NET49
+  VDDPE VNWP P11LL_CKT W=0.34U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXNA1 _CKB._CTL_PRECHBL.NET49 DFTRETB VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXNA2 _CKB._CTL_PRECHBL.NET49
+  _CKB._CTL_PRECHBL.NET047 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXPA1 _CKB._CTL_PRECHBL.NET49 DFTRETB
+  _CKB._CTL_PRECHBL.I69.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXPA2 _CKB._CTL_PRECHBL.I69.P1
+  _CKB._CTL_PRECHBL.NET047 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNA1 _CKB._CTL_PRECHBL.NBLPRECH_R _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I72.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNA2 _CKB._CTL_PRECHBL.I72.A1A2
+  _CKB._CTL_PRECHBL.DGTP_R VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNB1 _CKB._CTL_PRECHBL.NBLPRECH_R TIELODBLB VSSE VPW
+  N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPA1 _CKB._CTL_PRECHBL.NBLPRECH_R _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPA2 _CKB._CTL_PRECHBL.NBLPRECH_R
+  _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPB1 _CKB._CTL_PRECHBL.I72.A1A2UP TIELODBLB VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNA1 _CKB._CTL_PRECHBL.NBLPRECH_L _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I73.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNA2 _CKB._CTL_PRECHBL.I73.A1A2
+  _CKB._CTL_PRECHBL.DGTP_L VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNB1 _CKB._CTL_PRECHBL.NBLPRECH_L TIELODBLB VSSE VPW
+  N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPA1 _CKB._CTL_PRECHBL.NBLPRECH_L _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPA2 _CKB._CTL_PRECHBL.NBLPRECH_L
+  _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPB1 _CKB._CTL_PRECHBL.I73.A1A2UP TIELODBLB VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._ctl_prechbl.I75.MXNA1 _CKB._CTL_PRECHBL.NET0130
+  _CKB._CTL_PRECHBL.NET0124 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I75.MXPA1 _CKB._CTL_PRECHBL.NET0130
+  _CKB._CTL_PRECHBL.NET0124 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I76.MXNA1 _CKB._CTL_PRECHBL.NET0124 _CKB.NGTPB VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I76.MXPA1 _CKB._CTL_PRECHBL.NET0124 _CKB.NGTPB VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_ckb._iretb.MXNA1 DFTRETB _CKB.NDFTRETB VSSE VPW N11LL_CKT W=3.66U L=0.04U
X_M_ckb._iretb.MXPA1 DFTRETB _CKB.NDFTRETB VDDCE VNWC P11LL_CKT W=5.465U
+  L=0.04U
X_M_ckb._mem_tiehilo.MXN0 TIELODBLB _CKB._MEM_TIEHILO.NODEB VSSE VPW N11LL_CKT
+  W=1.42U L=0.04U
X_M_ckb._mem_tiehilo.MXN1 _CKB._MEM_TIEHILO.NODEA _CKB._MEM_TIEHILO.NODEA VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckb._mem_tiehilo.MXN2 _CKB._MEM_TIEHILO.NODEA _CKB._MEM_TIEHILO.NODEB VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckb._mem_tiehilo.MXP1 _CKB._MEM_TIEHILO.NODEB _CKB._MEM_TIEHILO.NODEA
+  VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_M_ckb._mem_tiehilo.MXP4 TIEHIB _CKB._MEM_TIEHILO.NODEA VDDPE VNWP P11LL_CKT
+  W=2.04U L=0.04U
X_M_ckb._nr_ret.MXNA1 _CKB.NDFTRETB RET VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_M_ckb._nr_ret.MXNA2 _CKB.NDFTRETB DFTRAMBYPB VSSE VPW N11LL_CKT W=0.65U
+  L=0.04U
X_M_ckb._nr_ret.MXP0 _CKB.NDFTRETB RET _CKB._NR_RET.P2 VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXP1 _CKB._NR_RET.P2 DFTRAMBYPB VDDCE VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXPA1 _CKB.NDFTRETB RET _CKB._NR_RET.P1 VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXPA2 _CKB._NR_RET.P1 DFTRAMBYPB VDDCE VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_coldet.I187.I81.MXNA1 _COLDET.I187.XAN RAA_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I187.I81.MXPA1 _COLDET.I187.XAN RAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I187.I82.MXNA1 _COLDET.I187.XBN RAB_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I187.I82.MXPA1 _COLDET.I187.XBN RAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I187.MXN5 _COLDET.I187.N1 RAB_P2[0] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I187.MXN6 _COLDET.XMT0 _COLDET.I187.XAN _COLDET.I187.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I187.MXN7 _COLDET.XMT0 RAA_P2[0] _COLDET.I187.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I187.MXN8 _COLDET.I187.N0 _COLDET.I187.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I187.MXP5 _COLDET.I187.P1 _COLDET.I187.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I187.MXP6 _COLDET.XMT0 _COLDET.I187.XBN _COLDET.I187.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I187.MXP7 _COLDET.XMT0 RAA_P2[0] _COLDET.I187.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I187.MXP8 _COLDET.I187.P0 RAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I188.I81.MXNA1 _COLDET.I188.XAN RAA_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I188.I81.MXPA1 _COLDET.I188.XAN RAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I188.I82.MXNA1 _COLDET.I188.XBN RAB_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I188.I82.MXPA1 _COLDET.I188.XBN RAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I188.MXN5 _COLDET.I188.N1 RAB_P2[1] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I188.MXN6 _COLDET.XMT1 _COLDET.I188.XAN _COLDET.I188.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I188.MXN7 _COLDET.XMT1 RAA_P2[1] _COLDET.I188.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I188.MXN8 _COLDET.I188.N0 _COLDET.I188.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I188.MXP5 _COLDET.I188.P1 _COLDET.I188.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I188.MXP6 _COLDET.XMT1 _COLDET.I188.XBN _COLDET.I188.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I188.MXP7 _COLDET.XMT1 RAA_P2[1] _COLDET.I188.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I188.MXP8 _COLDET.I188.P0 RAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I189.I81.MXNA1 _COLDET.I189.XAN RAA_P2[2] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I189.I81.MXPA1 _COLDET.I189.XAN RAA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I189.I82.MXNA1 _COLDET.I189.XBN RAB_P2[2] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I189.I82.MXPA1 _COLDET.I189.XBN RAB_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I189.MXN5 _COLDET.I189.N1 RAB_P2[2] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I189.MXN6 _COLDET.XMT2 _COLDET.I189.XAN _COLDET.I189.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I189.MXN7 _COLDET.XMT2 RAA_P2[2] _COLDET.I189.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I189.MXN8 _COLDET.I189.N0 _COLDET.I189.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I189.MXP5 _COLDET.I189.P1 _COLDET.I189.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I189.MXP6 _COLDET.XMT2 _COLDET.I189.XBN _COLDET.I189.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I189.MXP7 _COLDET.XMT2 RAA_P2[2] _COLDET.I189.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I189.MXP8 _COLDET.I189.P0 RAB_P2[2] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I190.I81.MXNA1 _COLDET.I190.XAN RAA_P2[5] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I190.I81.MXPA1 _COLDET.I190.XAN RAA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I190.I82.MXNA1 _COLDET.I190.XBN RAB_P2[5] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I190.I82.MXPA1 _COLDET.I190.XBN RAB_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I190.MXN5 _COLDET.I190.N1 RAB_P2[5] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I190.MXN6 _COLDET.XMT5 _COLDET.I190.XAN _COLDET.I190.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I190.MXN7 _COLDET.XMT5 RAA_P2[5] _COLDET.I190.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I190.MXN8 _COLDET.I190.N0 _COLDET.I190.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I190.MXP5 _COLDET.I190.P1 _COLDET.I190.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I190.MXP6 _COLDET.XMT5 _COLDET.I190.XBN _COLDET.I190.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I190.MXP7 _COLDET.XMT5 RAA_P2[5] _COLDET.I190.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I190.MXP8 _COLDET.I190.P0 RAB_P2[5] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I191.I81.MXNA1 _COLDET.I191.XAN RAA_P2[4] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I191.I81.MXPA1 _COLDET.I191.XAN RAA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I191.I82.MXNA1 _COLDET.I191.XBN RAB_P2[4] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I191.I82.MXPA1 _COLDET.I191.XBN RAB_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I191.MXN5 _COLDET.I191.N1 RAB_P2[4] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I191.MXN6 _COLDET.XMT4 _COLDET.I191.XAN _COLDET.I191.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I191.MXN7 _COLDET.XMT4 RAA_P2[4] _COLDET.I191.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I191.MXN8 _COLDET.I191.N0 _COLDET.I191.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I191.MXP5 _COLDET.I191.P1 _COLDET.I191.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I191.MXP6 _COLDET.XMT4 _COLDET.I191.XBN _COLDET.I191.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I191.MXP7 _COLDET.XMT4 RAA_P2[4] _COLDET.I191.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I191.MXP8 _COLDET.I191.P0 RAB_P2[4] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I192.I81.MXNA1 _COLDET.I192.XAN RAA_P2[3] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I192.I81.MXPA1 _COLDET.I192.XAN RAA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I192.I82.MXNA1 _COLDET.I192.XBN RAB_P2[3] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I192.I82.MXPA1 _COLDET.I192.XBN RAB_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I192.MXN5 _COLDET.I192.N1 RAB_P2[3] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I192.MXN6 _COLDET.XMT3 _COLDET.I192.XAN _COLDET.I192.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I192.MXN7 _COLDET.XMT3 RAA_P2[3] _COLDET.I192.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I192.MXN8 _COLDET.I192.N0 _COLDET.I192.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I192.MXP5 _COLDET.I192.P1 _COLDET.I192.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I192.MXP6 _COLDET.XMT3 _COLDET.I192.XBN _COLDET.I192.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I192.MXP7 _COLDET.XMT3 RAA_P2[3] _COLDET.I192.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I192.MXP8 _COLDET.I192.P0 RAB_P2[3] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I193.I81.MXNA1 _COLDET.I193.XAN LAA_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I193.I81.MXPA1 _COLDET.I193.XAN LAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I193.I82.MXNA1 _COLDET.I193.XBN LAB_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I193.I82.MXPA1 _COLDET.I193.XBN LAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I193.MXN5 _COLDET.I193.N1 LAB_P2[0] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I193.MXN6 _COLDET.XMT6 _COLDET.I193.XAN _COLDET.I193.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I193.MXN7 _COLDET.XMT6 LAA_P2[0] _COLDET.I193.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I193.MXN8 _COLDET.I193.N0 _COLDET.I193.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I193.MXP5 _COLDET.I193.P1 _COLDET.I193.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I193.MXP6 _COLDET.XMT6 _COLDET.I193.XBN _COLDET.I193.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I193.MXP7 _COLDET.XMT6 LAA_P2[0] _COLDET.I193.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I193.MXP8 _COLDET.I193.P0 LAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I196.MXNA1 _COLDET.XMT1N _COLDET.XMT2 _COLDET.I196.N2 VPW N11LL_CKT
+  W=0.515U L=0.04U
X_M_coldet.I196.MXNA2 _COLDET.I196.N2 _COLDET.XMT1 _COLDET.I196.N1 VPW
+  N11LL_CKT W=0.515U L=0.04U
X_M_coldet.I196.MXNA3 _COLDET.I196.N1 _COLDET.XMT0 VSS VPW N11LL_CKT W=0.515U
+  L=0.04U
X_M_coldet.I196.MXPA1 _COLDET.XMT1N _COLDET.XMT2 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I196.MXPA2 _COLDET.XMT1N _COLDET.XMT1 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I196.MXPA3 _COLDET.XMT1N _COLDET.XMT0 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I199.MXNA1 _COLDET.XMT2N _COLDET.XMT5 _COLDET.I199.N2 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_M_coldet.I199.MXNA2 _COLDET.I199.N2 _COLDET.XMT4 _COLDET.I199.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_coldet.I199.MXNA3 _COLDET.I199.N1 _COLDET.XMT3 VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_coldet.I199.MXPA1 _COLDET.XMT2N _COLDET.XMT5 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I199.MXPA2 _COLDET.XMT2N _COLDET.XMT4 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I199.MXPA3 _COLDET.XMT2N _COLDET.XMT3 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I206.MXNA1 _COLDET.X1MT _COLDET.XMT2N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I206.MXNA2 _COLDET.X1MT _COLDET.XMT1N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I206.MXPA1 _COLDET.X1MT _COLDET.XMT2N _COLDET.I206.P1 VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_M_coldet.I206.MXPA2 _COLDET.I206.P1 _COLDET.XMT1N VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_coldet.I219.MXNA1 _COLDET.GCKMT _COLDET.GCKMTN VSSE VPW N11LL_CKT W=0.2U
+  L=0.04U
X_M_coldet.I219.MXPA1 _COLDET.GCKMT _COLDET.GCKMTN VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_coldet.I237.I81.MXNA1 _COLDET.I237.XAN LAA_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I237.I81.MXPA1 _COLDET.I237.XAN LAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I237.I82.MXNA1 _COLDET.I237.XBN LAB_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I237.I82.MXPA1 _COLDET.I237.XBN LAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I237.MXN5 _COLDET.I237.N1 LAB_P2[1] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I237.MXN6 _COLDET.NET78 _COLDET.I237.XAN _COLDET.I237.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I237.MXN7 _COLDET.NET78 LAA_P2[1] _COLDET.I237.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I237.MXN8 _COLDET.I237.N0 _COLDET.I237.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I237.MXP5 _COLDET.I237.P1 _COLDET.I237.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I237.MXP6 _COLDET.NET78 _COLDET.I237.XBN _COLDET.I237.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I237.MXP7 _COLDET.NET78 LAA_P2[1] _COLDET.I237.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I237.MXP8 _COLDET.I237.P0 LAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I240.MXNA1 _COLDET.GCKMTN GTPA _COLDET.I240.N1 VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_coldet.I240.MXNA2 _COLDET.I240.N1 GTPB VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_coldet.I240.MXPA1 _COLDET.GCKMTN GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_coldet.I240.MXPA2 _COLDET.GCKMTN GTPB VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_coldet.I241.MXNA1 _COLDET.XMT3N _COLDET.XMT6 _COLDET.I241.N2 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_M_coldet.I241.MXNA2 _COLDET.I241.N2 _COLDET.NET78 _COLDET.I241.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_coldet.I241.MXNA3 _COLDET.I241.N1 MOD_COLDISN VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_coldet.I241.MXPA1 _COLDET.XMT3N _COLDET.XMT6 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I241.MXPA2 _COLDET.XMT3N _COLDET.NET78 VDDPE VNWP P11LL_CKT
+  W=0.255U L=0.04U
X_M_coldet.I241.MXPA3 _COLDET.XMT3N MOD_COLDISN VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I244.MXNA1 _COLDET.X2MT _COLDET.XMT3N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I244.MXPA1 _COLDET.X2MT _COLDET.XMT3N VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I57.MXNA1 NFORCERDBL _COLDET.GCKMT _COLDET.I57.N2 VPW N11LL_CKT
+  W=0.9U L=0.04U
X_M_coldet.I57.MXNA2 _COLDET.I57.N2 _COLDET.X1MT _COLDET.I57.N1 VPW N11LL_CKT
+  W=0.9U L=0.04U
X_M_coldet.I57.MXNA3 _COLDET.I57.N1 _COLDET.X2MT VSS VPW N11LL_CKT W=0.9U
+  L=0.04U
X_M_coldet.I57.MXPA1 NFORCERDBL _COLDET.GCKMT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
X_M_coldet.I57.MXPA2 NFORCERDBL _COLDET.X1MT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
X_M_coldet.I57.MXPA3 NFORCERDBL _COLDET.X2MT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
.ENDS RAMTP1024X16CKM4_BASIC
****
.SUBCKT RAMTP1024X16CTRL_COLT CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB COLLDISN
+  DBLA DBLB DFTRAMBYPA DFTRETA DFTRETB DWLA DWLAV DWLB DWLBTURN EMAA0 EMAA1
+  EMAA2 EMAB0 EMAB1 EMAB2 GTPA GTPB LAA0 LAA1 LAA_P2[0] LAA_P2[1] LAB0 LAB1
+  LAB_P2[0] LAB_P2[1] NSAE NYPACLK[0] NYPACLK[1] NYPACLK[2] NYPACLK[3]
+  PRECHA_L PRECHA_R PRECHB_L PRECHB_R RAA0 RAA1 RAA2 RAA3 RAA4 RAA5 RAA_P2[0]
+  RAA_P2[1] RAA_P2[2] RAA_P2[3] RAA_P2[4] RAA_P2[5] RAB0 RAB1 RAB2 RAB3 RAB4
+  RAB5 RAB_P2[0] RAB_P2[1] RAB_P2[2] RAB_P2[3] RAB_P2[4] RAB_P2[5] RET1N
+  SAPRECH TIEHIA TIEHIB TIELOCDA TIELOCDB TIELODBLA TIELODBLB TIELOFPB
+  VDDC_WLA VNWC VNWP VPW WCLK WEN YPBCLK[0] YPBCLK[1] YPBCLK[2] YPBCLK[3]
+  YPCOL[0] YPCOL[1] YPCOL[2] YPCOL[3]
** RAMTP1024X16CTRL_COLT: 1048 flat devices **
XCKCELL CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB COLLDISN DBLA DBLB DFTRAMBYPA
+  TIELOFPB DFTRETA DFTRETB DWLA DWLAV DWLAV DWLB DWLBTURN DWLBTURN EMAA0
+  EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA GTPB ISAE_DUM0 ISAE_DUM1 LAA0 LAA1
+  LAA_P2[0] LAA_P2[1] LAB0 LAB1 LAB_P2[0] LAB_P2[1] VPW VPW NSAE NYPACLK[0]
+  NYPACLK[1] NYPACLK[2] NYPACLK[3] PRECHA_L PRECHA_R PRECHB_L PRECHB_R RAA0
+  RAA1 RAA2 RAA3 RAA4 RAA5 RAA_P2[0] RAA_P2[1] RAA_P2[2] RAA_P2[3] RAA_P2[4]
+  RAA_P2[5] RAB0 RAB1 RAB2 RAB3 RAB4 RAB5 RAB_P2[0] RAB_P2[1] RAB_P2[2]
+  RAB_P2[3] RAB_P2[4] RAB_P2[5] DFTRAMBYPA RET1N SAE_DUMMY SAE_DUMMY SAEDO1
+  SAE_DUMMY SAPRECH DFTRAMBYPA TIELOFPB TIEHIA TIEHIB TIELOCDA TIELOCDB
+  TIELODBLA TIELODBLB DFTRAMBYPA TIELOFPB VDDC_WLA VDDC_WLA VDDC_WLA VNWP
+  VNWP VNWP VNWC VNWP VPW VPW VPW WCLK WEN YPBCLK[0] YPBCLK[1] YPBCLK[2]
+  YPBCLK[3] YPCOL[0] YPCOL[1] YPCOL[2] YPCOL[3] RAMTP1024X16CKM4_BASIC
XFPCTRLCELL CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB COLLDISN DFTRAMBYPA
+  TIELOFPB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 LAA0 LAA1 LAB0 LAB1 VNWP RAA0
+  RAA1 RAA2 RAA3 RAA4 RAA5 RAB0 RAB1 RAB2 RAB3 RAB4 RAB5 DFTRAMBYPA RET1N VPW
+  DFTRAMBYPA TIELOFPB DFTRAMBYPA TIELOFPB VDDC_WLA VNWP VNWC VNWP VPW VPW VPW
+  RAMTP1024X16FPCTRL_BASIC
.ENDS RAMTP1024X16CTRL_COLT
****
.SUBCKT RAMTP1024X16CORE_COLX_R BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA0_8 BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15
+  BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9
+  BLA1_10 BLA1_11 BLA1_12 BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13
+  BLB0_14 BLB0_15 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7
+  BLB1_8 BLB1_9 BLB1_10 BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9
+  NBLA0_10 NBLA0_11 NBLA0_12 NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10
+  NBLA1_11 NBLA1_12 NBLA1_13 NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2
+  NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11
+  NBLB0_12 NBLB0_13 NBLB0_14 NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4
+  NBLB1_5 NBLB1_6 NBLB1_7 NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13
+  NBLB1_14 NBLB1_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 VSS_8
+  VSS_9 VSS_10 VSS_11 VSS_12 VSS_13 VSS_14 VSS_15 WLA0_0 WLA0_1 WLA0_2 WLA0_3
+  WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13
+  WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22
+  WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31
+  WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40
+  WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49
+  WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58
+  WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67
+  WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76
+  WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85
+  WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94
+  WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103
+  WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111
+  WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119
+  WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127
+  WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63
+  WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72
+  WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81
+  WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90
+  WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99
+  WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107
+  WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115
+  WLA1_116 WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123
+  WLA1_124 WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4
+  WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14
+  WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23
+  WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32
+  WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41
+  WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50
+  WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59
+  WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68
+  WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77
+  WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86
+  WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95
+  WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103
+  WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111
+  WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119
+  WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127
+  WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36
+  WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45
+  WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54
+  WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63
+  WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72
+  WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81
+  WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90
+  WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99
+  WLB1_100 WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107
+  WLB1_108 WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115
+  WLB1_116 WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123
+  WLB1_124 WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16CORE_COLX_R: 66560 flat devices **
XCC2X2_COL_FARWD BLA0_14 BLA1_14 BLB0_14 BLB1_14 NBLA0_14 NBLA1_14 NBLB0_14
+  NBLB1_14 VDDC VDDPE_14 VPW VSS_14 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_FARWD_23 BLA0_15 BLA1_15 BLB0_15 BLB1_15 NBLA0_15 NBLA1_15 NBLB0_15
+  NBLB1_15 VDDC VDDPE_15 VPW VSS_15 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 NBLA0_0 NBLA1_0 NBLB0_0 NBLB1_0
+  VDDC VDDPE_0 VPW VSS_0 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_NEARWD_23 BLA0_1 BLA1_1 BLB0_1 BLB1_1 NBLA0_1 NBLA1_1 NBLB0_1
+  NBLB1_1 VDDC VDDPE_1 VPW VSS_1 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_10 BLA0_10 BLA1_10 BLB0_10 BLB1_10 NBLA0_10 NBLA1_10 NBLB0_10
+  NBLB1_10 VDDC VDDPE_10 VPW VSS_10 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_11 BLA0_11 BLA1_11 BLB0_11 BLB1_11 NBLA0_11 NBLA1_11 NBLB0_11
+  NBLB1_11 VDDC VDDPE_11 VPW VSS_11 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_12 BLA0_12 BLA1_12 BLB0_12 BLB1_12 NBLA0_12 NBLA1_12 NBLB0_12
+  NBLB1_12 VDDC VDDPE_12 VPW VSS_12 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_13 BLA0_13 BLA1_13 BLB0_13 BLB1_13 NBLA0_13 NBLA1_13 NBLB0_13
+  NBLB1_13 VDDC VDDPE_13 VPW VSS_13 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  VDDC VDDPE_2 VPW VSS_2 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  VDDC VDDPE_3 VPW VSS_3 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  VDDC VDDPE_4 VPW VSS_4 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  VDDC VDDPE_5 VPW VSS_5 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  VDDC VDDPE_6 VPW VSS_6 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_7 BLA0_7 BLA1_7 BLB0_7 BLB1_7 NBLA0_7 NBLA1_7 NBLB0_7 NBLB1_7
+  VDDC VDDPE_7 VPW VSS_7 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_8 BLA0_8 BLA1_8 BLB0_8 BLB1_8 NBLA0_8 NBLA1_8 NBLB0_8 NBLB1_8
+  VDDC VDDPE_8 VPW VSS_8 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XRCC_COL_MUX1_9 BLA0_9 BLA1_9 BLB0_9 BLB1_9 NBLA0_9 NBLA1_9 NBLB0_9 NBLB1_9
+  VDDC VDDPE_9 VPW VSS_9 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
.ENDS RAMTP1024X16CORE_COLX_R
****
.SUBCKT RAMTP1024X16CORE_COLXR BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA0_8 BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15
+  BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9
+  BLA1_10 BLA1_11 BLA1_12 BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13
+  BLB0_14 BLB0_15 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7
+  BLB1_8 BLB1_9 BLB1_10 BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9
+  NBLA0_10 NBLA0_11 NBLA0_12 NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10
+  NBLA1_11 NBLA1_12 NBLA1_13 NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2
+  NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11
+  NBLB0_12 NBLB0_13 NBLB0_14 NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4
+  NBLB1_5 NBLB1_6 NBLB1_7 NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13
+  NBLB1_14 NBLB1_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16CORE_COLXR: 66560 flat devices **
XCORE_COLXS_R BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA0_8
+  BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15 BLA1_0 BLA1_1 BLA1_2
+  BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9 BLA1_10 BLA1_11 BLA1_12
+  BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13 BLB0_14 BLB0_15 BLB1_0
+  BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB1_8 BLB1_9 BLB1_10
+  BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9 NBLA0_10 NBLA0_11 NBLA0_12
+  NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10 NBLA1_11 NBLA1_12 NBLA1_13
+  NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11 NBLB0_12 NBLB0_13 NBLB0_14
+  NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13 NBLB1_14 NBLB1_15 VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW WLA0_0 WLA0_1
+  WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11
+  WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20
+  WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29
+  WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38
+  WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47
+  WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56
+  WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65
+  WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74
+  WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83
+  WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92
+  WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101
+  WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109
+  WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117
+  WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125
+  WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7
+  WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16
+  WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25
+  WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34
+  WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43
+  WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52
+  WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61
+  WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70
+  WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79
+  WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88
+  WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97
+  WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105
+  WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113
+  WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121
+  WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2
+  WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12
+  WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21
+  WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30
+  WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39
+  WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48
+  WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57
+  WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66
+  WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75
+  WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84
+  WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93
+  WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102
+  WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110
+  WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118
+  WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126
+  WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8
+  WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17
+  WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26
+  WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35
+  WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44
+  WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53
+  WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62
+  WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71
+  WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80
+  WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89
+  WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98
+  WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106
+  WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114
+  WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122
+  WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CORE_COLX_R
.ENDS RAMTP1024X16CORE_COLXR
****
.SUBCKT RAMTP1024X16CD_COLXREG_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLA2_0 BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1
+  BLA3_2 BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5
+  BLB1_6 BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7
+  BLB3_0 BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2
+  NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3
+  NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6
+  NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4
+  WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0
+  YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16CD_COLXREG_RT: 1000 flat devices **
XCD_1 BLA0_1 BLA1_1 BLA2_1 BLA3_1 BLB0_1 BLB1_1 BLB2_1 BLB3_1 DFT DWL DWL
+  NBLA0_1 NBLA1_1 NBLA2_1 NBLA3_1 NBLB0_1 NBLB1_1 NBLB2_1 NBLB3_1 NSAE
+  NWRDATA_1 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_1 SAPRECH
+  RD_0 RD_1 TIELO VDDC_1 VDDCE_1 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_1
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_2 BLA0_2 BLA1_2 BLA2_2 BLA3_2 BLB0_2 BLB1_2 BLB2_2 BLB3_2 DFT DWL DWL
+  NBLA0_2 NBLA1_2 NBLA2_2 NBLA3_2 NBLB0_2 NBLB1_2 NBLB2_2 NBLB3_2 NSAE
+  NWRDATA_2 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_2 SAPRECH
+  RD_1 RD_2 TIELO VDDC_2 VDDCE_2 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_2
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_3 BLA0_3 BLA1_3 BLA2_3 BLA3_3 BLB0_3 BLB1_3 BLB2_3 BLB3_3 DFT DWL DWL
+  NBLA0_3 NBLA1_3 NBLA2_3 NBLA3_3 NBLB0_3 NBLB1_3 NBLB2_3 NBLB3_3 NSAE
+  NWRDATA_3 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_3 SAPRECH
+  RD_2 RD_3 TIELO VDDC_3 VDDCE_3 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_3
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_4 BLA0_4 BLA1_4 BLA2_4 BLA3_4 BLB0_4 BLB1_4 BLB2_4 BLB3_4 DFT DWL DWL
+  NBLA0_4 NBLA1_4 NBLA2_4 NBLA3_4 NBLB0_4 NBLB1_4 NBLB2_4 NBLB3_4 NSAE
+  NWRDATA_4 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_4 SAPRECH
+  RD_3 RD_4 TIELO VDDC_4 VDDCE_4 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_4
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_5 BLA0_5 BLA1_5 BLA2_5 BLA3_5 BLB0_5 BLB1_5 BLB2_5 BLB3_5 DFT DWL DWL
+  NBLA0_5 NBLA1_5 NBLA2_5 NBLA3_5 NBLB0_5 NBLB1_5 NBLB2_5 NBLB3_5 NSAE
+  NWRDATA_5 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_5 SAPRECH
+  RD_4 RD_5 TIELO VDDC_5 VDDCE_5 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_5
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_6 BLA0_6 BLA1_6 BLA2_6 BLA3_6 BLB0_6 BLB1_6 BLB2_6 BLB3_6 DFT DWL DWL
+  NBLA0_6 NBLA1_6 NBLA2_6 NBLA3_6 NBLB0_6 NBLB1_6 NBLB2_6 NBLB3_6 NSAE
+  NWRDATA_6 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_6 SAPRECH
+  RD_5 RD_6 TIELO VDDC_6 VDDCE_6 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_6
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_FARWD BLA0_7 BLA1_7 BLA2_7 BLA3_7 BLB0_7 BLB1_7 BLB2_7 BLB3_7 DFT DWL DWL
+  NBLA0_7 NBLA1_7 NBLA2_7 NBLA3_7 NBLB0_7 NBLB1_7 NBLB2_7 NBLB3_7 NSAE
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB SO SAPRECH RD_6
+  SO TIELO VDDC_7 VDDCE_7 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_7 YPCLK0B
+  YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_NEARWD BLA0_0 BLA1_0 BLA2_0 BLA3_0 BLB0_0 BLB1_0 BLB2_0 BLB3_0 DFT DWL DWL
+  NBLA0_0 NBLA1_0 NBLA2_0 NBLA3_0 NBLB0_0 NBLB1_0 NBLB2_0 NBLB3_0 NSAE
+  NWRDATA_0 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 SAPRECH SI
+  RD_0 TIELO VDDC_0 VDDCE_0 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_0 YPCLK0B
+  YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
.ENDS RAMTP1024X16CD_COLXREG_RT
****
.SUBCKT RAMTP1024X16CD_COLX_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLA2_0 BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1
+  BLA3_2 BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5
+  BLB1_6 BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7
+  BLB3_0 BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2
+  NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3
+  NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6
+  NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4
+  WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0
+  YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16CD_COLX_RT: 1000 flat devices **
XCD_COLXREG_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0 BLA2_1 BLA2_2
+  BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2 BLA3_3 BLA3_4
+  BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB2_0
+  BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0 BLB3_1 BLB3_2
+  BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5
+  NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6
+  NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0
+  NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1
+  NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7 NSAE NWRDATA_0 NWRDATA_1
+  NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6 NWRDATA_7 NYPCLK0A
+  NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC
+  VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5 WRDATA_6 WRDATA_7
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CD_COLXREG_RT
.ENDS RAMTP1024X16CD_COLX_RT
****
.SUBCKT RAMTP1024X16WRGRTNHD D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS WEN
+  WENY
** RAMTP1024X16WRGRTNHD: 4 flat devices **
XI0 D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS VSS WEN WENY
+  RAMTP1024X16FLBIOM4
.ENDS RAMTP1024X16WRGRTNHD
****
.SUBCKT RAMTP1024X16XR_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TIELO TWEN_0 TWEN_1
+  TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VNWP VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6
+  VSS_7 WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1
+  WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP1024X16XR_COLX_RT: 32 flat devices **
XI0 D_0 Q_0 TD_0 TIELO TWEN_0 VDDCE_0 VDDPE_0 VNWP VPW VSS_0 WEN_0 WENY_0
+  RAMTP1024X16WRGRTNHD
XI1 D_1 Q_1 TD_1 TIELO TWEN_1 VDDCE_1 VDDPE_1 VNWP VPW VSS_1 WEN_1 WENY_1
+  RAMTP1024X16WRGRTNHD
XI2 D_2 Q_2 TD_2 TIELO TWEN_2 VDDCE_2 VDDPE_2 VNWP VPW VSS_2 WEN_2 WENY_2
+  RAMTP1024X16WRGRTNHD
XI3 D_3 Q_3 TD_3 TIELO TWEN_3 VDDCE_3 VDDPE_3 VNWP VPW VSS_3 WEN_3 WENY_3
+  RAMTP1024X16WRGRTNHD
XI4 D_4 Q_4 TD_4 TIELO TWEN_4 VDDCE_4 VDDPE_4 VNWP VPW VSS_4 WEN_4 WENY_4
+  RAMTP1024X16WRGRTNHD
XI5 D_5 Q_5 TD_5 TIELO TWEN_5 VDDCE_5 VDDPE_5 VNWP VPW VSS_5 WEN_5 WENY_5
+  RAMTP1024X16WRGRTNHD
XI6 D_6 Q_6 TD_6 TIELO TWEN_6 VDDCE_6 VDDPE_6 VNWP VPW VSS_6 WEN_6 WENY_6
+  RAMTP1024X16WRGRTNHD
XI7 D_7 Q_7 TD_7 TIELO TWEN_7 VDDCE_7 VDDPE_7 VNWP VPW VSS_7 WEN_7 WENY_7
+  RAMTP1024X16WRGRTNHD
.ENDS RAMTP1024X16XR_COLX_RT
****
.SUBCKT RAMTP1024X16WR_COLX_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 RD_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE VPW VSS WCLK WENL WENR WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WRONE_0 WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7
+  WRZERO_0 WRZERO_1 WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7
** RAMTP1024X16WR_COLX_R: 384 flat devices **
XWR_1 D_1 RD_1 VDDCE_1 VDDPE VDDPE VPW VSS VSS WCLK WEN_1 WEN_0 WEN_1 WRONE_1
+  WRZERO_1 RAMTP1024X16WRM4_WM
XWR_2 D_2 RD_2 VDDCE_2 VDDPE VDDPE VPW VSS VSS WCLK WEN_2 WEN_1 WEN_2 WRONE_2
+  WRZERO_2 RAMTP1024X16WRM4_WM
XWR_3 D_3 RD_3 VDDCE_3 VDDPE VDDPE VPW VSS VSS WCLK WEN_3 WEN_2 WEN_3 WRONE_3
+  WRZERO_3 RAMTP1024X16WRM4_WM
XWR_4 D_4 RD_4 VDDCE_4 VDDPE VDDPE VPW VSS VSS WCLK WEN_4 WEN_3 WEN_4 WRONE_4
+  WRZERO_4 RAMTP1024X16WRM4_WM
XWR_5 D_5 RD_5 VDDCE_5 VDDPE VDDPE VPW VSS VSS WCLK WEN_5 WEN_4 WEN_5 WRONE_5
+  WRZERO_5 RAMTP1024X16WRM4_WM
XWR_6 D_6 RD_6 VDDCE_6 VDDPE VDDPE VPW VSS VSS WCLK WEN_6 WEN_5 WEN_6 WRONE_6
+  WRZERO_6 RAMTP1024X16WRM4_WM
XWR_FARWD D_7 RD_7 VDDCE_7 VDDPE VDDPE VPW VSS VSS WCLK WENR WEN_6 WENR
+  WRONE_7 WRZERO_7 RAMTP1024X16WRM4_WM
XWR_NEARWD D_0 RD_0 VDDCE_0 VDDPE VDDPE VPW VSS VSS WCLK WEN_0 WENL WEN_0
+  WRONE_0 WRZERO_0 RAMTP1024X16WRM4_WM
.ENDS RAMTP1024X16WR_COLX_R
****
.SUBCKT RAMTP1024X16RD_COLX_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 RD0_0 RD0_1 RD0_2 RD0_3 RD0_4 RD0_5 RD0_6 RD0_7 TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDPE VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0
+  VPW_1 VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSSE_0 VSSE_1 VSSE_2 VSSE_3
+  VSSE_4 VSSE_5 VSSE_6 VSSE_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7
+  WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2
+  WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP1024X16RD_COLX_R: 16 flat devices **
XRD_1 D_1 Q_1 RD0_1 TD_1 TWEN_1 VDDCE_1 VDDPE VNWP_1 VPW_1 VSS_1 VSSE_1 WEN_1
+  WENY_1 RAMTP1024X16RDM4
XRD_2 D_2 Q_2 RD0_2 TD_2 TWEN_2 VDDCE_2 VDDPE VNWP_2 VPW_2 VSS_2 VSSE_2 WEN_2
+  WENY_2 RAMTP1024X16RDM4
XRD_3 D_3 Q_3 RD0_3 TD_3 TWEN_3 VDDCE_3 VDDPE VNWP_3 VPW_3 VSS_3 VSSE_3 WEN_3
+  WENY_3 RAMTP1024X16RDM4
XRD_4 D_4 Q_4 RD0_4 TD_4 TWEN_4 VDDCE_4 VDDPE VNWP_4 VPW_4 VSS_4 VSSE_4 WEN_4
+  WENY_4 RAMTP1024X16RDM4
XRD_5 D_5 Q_5 RD0_5 TD_5 TWEN_5 VDDCE_5 VDDPE VNWP_5 VPW_5 VSS_5 VSSE_5 WEN_5
+  WENY_5 RAMTP1024X16RDM4
XRD_6 D_6 Q_6 RD0_6 TD_6 TWEN_6 VDDCE_6 VDDPE VNWP_6 VPW_6 VSS_6 VSSE_6 WEN_6
+  WENY_6 RAMTP1024X16RDM4
XRD_FARWD D_7 Q_7 RD0_7 TD_7 TWEN_7 VDDCE_7 VDDPE VNWP_7 VPW_7 VSS_7 VSSE_7
+  WEN_7 WENY_7 RAMTP1024X16RDM4
XRD_NEARWD D_0 Q_0 RD0_0 TD_0 TWEN_0 VDDCE_0 VDDPE VNWP_0 VPW_0 VSS_0 VSSE_0
+  WEN_0 WENY_0 RAMTP1024X16RDM4
.ENDS RAMTP1024X16RD_COLX_R
****
.SUBCKT RAMTP1024X16ENDBOT_COL_RT DFT DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYP2A_TERM NYP2B_TERM NYP3A_TERM
+  NYP3B_TERM NYPCOL0 NYPCOL1 NYPCOL2 NYPCOL3 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SIA TIELO_0 TIELO_1 VDDCE VDDPE_0 VDDPE_1 VDDPE_2 VNWC VNWP
+  VPW_0 VPW_1 VSSE VSS_0 VSS_1 WCLK WEN
** RAMTP1024X16ENDBOT_COL_RT: 10 flat devices **
XCDEDGECELL DFT DWL DWLTURN NSAE_TERM NYP0A_TERM NYP0B_TERM NYP1A_TERM
+  NYP1B_TERM NYP2A_TERM NYP2B_TERM NYP3A_TERM NYP3B_TERM NYPCOL0 NYPCOL1
+  NYPCOL2 NYPCOL3 PRECHA_TERM PRECHB_TERM SAPRECH_TERM SIA TIELO_0 SOA SOB
+  TIELO_1 VDDCE VDDPE_0 VNWC VDDPE_0 VPW_0 VSS_1 VSSE
+  RAMTP1024X16CDM4EDGE_BST
.ENDS RAMTP1024X16ENDBOT_COL_RT
****
.SUBCKT RAMTP1024X16BOT_IO_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0
+  BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2
+  BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4
+  BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6
+  BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0
+  BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6
+  NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7
+  NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0
+  NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1
+  NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2
+  NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3
+  NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4
+  NBLB3_5 NBLB3_6 NBLB3_7 NSAE NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA
+  PRECHB Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SI TIELO_0 TIELO_1 VDDCE_0
+  VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC VPW_0 VPW_1
+  VSSE WCLK WENL WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YPCLK0B
+  YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16BOT_IO_RT: 1442 flat devices **
XCD_COLX_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0 BLA2_1 BLA2_2
+  BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2 BLA3_3 BLA3_4
+  BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB2_0
+  BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0 BLB3_1 BLB3_2
+  BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5
+  NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6
+  NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0
+  NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1
+  NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7 NSAE NWRDATA_0 NWRDATA_1
+  NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6 NWRDATA_7 NYPCLK0A
+  NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  SAPRECH SI SO TIELO_1 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7
+  VDDPE VNWC VPW_0 WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1
+  YPCOLCLK2 YPCOLCLK3 RAMTP1024X16CD_COLX_RT
XENDBOT_COL_RT DFT DWL DWL NSAE NYPCLK0A YPCLK0B NYPCLK1A YPCLK1B NYPCLK2A
+  YPCLK2B NYPCLK3A YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3 PRECHA
+  PRECHB SAPRECH SO TIELO_0 TIELO_1 VDDCE_8 VDDPE VDDPE VDDPE VNWC VDDPE
+  VPW_0 VPW_1 VSSE VPW_0 VPW_0 WCLK WEN_7 RAMTP1024X16ENDBOT_COL_RT
XRD_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6 SO VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDCE_0 VDDCE_1
+  VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VPW_1 VPW_1 VPW_1 VPW_1 VPW_1 VPW_1 VPW_1
+  VPW_1 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMTP1024X16RD_COLX_R
XWR_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  SO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE
+  VPW_1 VPW_0 WCLK WENL WEN_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6
+  WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5 WRDATA_6 WRDATA_7
+  NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 RAMTP1024X16WR_COLX_R
XR_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 TIELO_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VPW_1 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 RAMTP1024X16XR_COLX_RT
.ENDS RAMTP1024X16BOT_IO_RT
****
.SUBCKT RAMTP1024X16TTOP CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB COLLDISN D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMAA0
+  EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 LAA0 LAA1 LAB0 LAB1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5
+  Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RAA0 RAA1 RAA2 RAA3 RAA4 RAA5
+  RAB0 RAB1 RAB2 RAB3 RAB4 RAB5 RET1N VDDCE VDDPE VSSE WEN_0 WEN_1 WEN_2
+  WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13
+  WEN_14 WEN_15
** RAMTP1024X16TTOP: 143099 flat devices **
XBOT_CTRL_COL CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB COLLDISN DBLA_OUT DBLB
+  SI RETA RETB DWLA DWLA DWLB DWLB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA1
+  GTPB0 LAA0 LAA1 LAA[0] LAA[1] LAB0 LAB1 LAB[0] LAB[1] NSAE NYPCLK0A
+  NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHA_R PRECHB PRECHB_R RAA0 RAA1 RAA2
+  RAA3 RAA4 RAA5 RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB0 RAB1 RAB2
+  RAB3 RAB4 RAB5 RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RET1N SAPRECH
+  LOG1A LOG1B TIELO_1 TIELOCDB LOG0_DWLA LOG0_DWLB TIELOFPB VDDCE VDDCE VDDPE
+  VSSE WCLK WEN_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1
+  YPCOLCLK2 YPCOLCLK3 RAMTP1024X16CTRL_COLT
XCORE_COLL BLA0_0 BLA2_0 BLA0_1 BLA2_1 BLA0_2 BLA2_2 BLA0_3 BLA2_3 BLA0_4
+  BLA2_4 BLA0_5 BLA2_5 BLA0_6 BLA2_6 BLA0_7 BLA2_7 BLA1_0 BLA3_0 BLA1_1
+  BLA3_1 BLA1_2 BLA3_2 BLA1_3 BLA3_3 BLA1_4 BLA3_4 BLA1_5 BLA3_5 BLA1_6
+  BLA3_6 BLA1_7 BLA3_7 BLB0_0 BLB2_0 BLB0_1 BLB2_1 BLB0_2 BLB2_2 BLB0_3
+  BLB2_3 BLB0_4 BLB2_4 BLB0_5 BLB2_5 BLB0_6 BLB2_6 BLB0_7 BLB2_7 BLB1_0
+  BLB3_0 BLB1_1 BLB3_1 BLB1_2 BLB3_2 BLB1_3 BLB3_3 BLB1_4 BLB3_4 BLB1_5
+  BLB3_5 BLB1_6 BLB3_6 BLB1_7 BLB3_7 NBLA0_0 NBLA2_0 NBLA0_1 NBLA2_1 NBLA0_2
+  NBLA2_2 NBLA0_3 NBLA2_3 NBLA0_4 NBLA2_4 NBLA0_5 NBLA2_5 NBLA0_6 NBLA2_6
+  NBLA0_7 NBLA2_7 NBLA1_0 NBLA3_0 NBLA1_1 NBLA3_1 NBLA1_2 NBLA3_2 NBLA1_3
+  NBLA3_3 NBLA1_4 NBLA3_4 NBLA1_5 NBLA3_5 NBLA1_6 NBLA3_6 NBLA1_7 NBLA3_7
+  NBLB0_0 NBLB2_0 NBLB0_1 NBLB2_1 NBLB0_2 NBLB2_2 NBLB0_3 NBLB2_3 NBLB0_4
+  NBLB2_4 NBLB0_5 NBLB2_5 NBLB0_6 NBLB2_6 NBLB0_7 NBLB2_7 NBLB1_0 NBLB3_0
+  NBLB1_1 NBLB3_1 NBLB1_2 NBLB3_2 NBLB1_3 NBLB3_3 NBLB1_4 NBLB3_4 NBLB1_5
+  NBLB3_5 NBLB1_6 NBLB3_6 NBLB1_7 NBLB3_7 VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VSSE
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36
+  WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45
+  WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54
+  WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63
+  WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72
+  WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81
+  WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90
+  WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99
+  WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106 WLA0_107
+  WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114 WLA0_115
+  WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122 WLA0_123
+  WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4
+  WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14
+  WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23
+  WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32
+  WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41
+  WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50
+  WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59
+  WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68
+  WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77
+  WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86
+  WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95
+  WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102 WLA1_103
+  WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110 WLA1_111
+  WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118 WLA1_119
+  WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126 WLA1_127
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36
+  WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45
+  WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54
+  WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63
+  WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72
+  WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81
+  WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90
+  WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99
+  WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107
+  WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115
+  WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123
+  WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4
+  WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14
+  WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23
+  WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32
+  WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41
+  WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50
+  WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59
+  WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68
+  WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77
+  WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86
+  WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95
+  WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119
+  WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127
+  RAMTP1024X16CORE_COLXL
XCORE_COLR BLA0_0_883 BLA0_1_867 BLA0_2_851 BLA0_3_835 BLA0_4_819 BLA0_5_803
+  BLA0_6_787 BLA0_7_771 BLA0_8 BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14
+  BLA0_15 BLA1_0_873 BLA1_1_857 BLA1_2_841 BLA1_3_825 BLA1_4_809 BLA1_5_793
+  BLA1_6_777 BLA1_7_761 BLA1_8 BLA1_9 BLA1_10 BLA1_11 BLA1_12 BLA1_13 BLA1_14
+  BLA1_15 BLB0_0_879 BLB0_1_863 BLB0_2_847 BLB0_3_831 BLB0_4_815 BLB0_5_799
+  BLB0_6_783 BLB0_7_767 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13 BLB0_14
+  BLB0_15 BLB1_0_877 BLB1_1_861 BLB1_2_845 BLB1_3_829 BLB1_4_813 BLB1_5_797
+  BLB1_6_781 BLB1_7_765 BLB1_8 BLB1_9 BLB1_10 BLB1_11 BLB1_12 BLB1_13 BLB1_14
+  BLB1_15 NBLA0_0_885 NBLA0_1_869 NBLA0_2_853 NBLA0_3_837 NBLA0_4_821
+  NBLA0_5_805 NBLA0_6_789 NBLA0_7_773 NBLA0_8 NBLA0_9 NBLA0_10 NBLA0_11
+  NBLA0_12 NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0_871 NBLA1_1_855 NBLA1_2_839
+  NBLA1_3_823 NBLA1_4_807 NBLA1_5_791 NBLA1_6_775 NBLA1_7_759 NBLA1_8 NBLA1_9
+  NBLA1_10 NBLA1_11 NBLA1_12 NBLA1_13 NBLA1_14 NBLA1_15 NBLB0_0_881
+  NBLB0_1_865 NBLB0_2_849 NBLB0_3_833 NBLB0_4_817 NBLB0_5_801 NBLB0_6_785
+  NBLB0_7_769 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11 NBLB0_12 NBLB0_13 NBLB0_14
+  NBLB0_15 NBLB1_0_875 NBLB1_1_859 NBLB1_2_843 NBLB1_3_827 NBLB1_4_811
+  NBLB1_5_795 NBLB1_6_779 NBLB1_7_763 NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11
+  NBLB1_12 NBLB1_13 NBLB1_14 NBLB1_15 VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VSSE
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36
+  WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45
+  WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54
+  WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63
+  WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72
+  WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81
+  WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90
+  WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99
+  WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106 WLA0_107
+  WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114 WLA0_115
+  WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122 WLA0_123
+  WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4
+  WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14
+  WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23
+  WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32
+  WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41
+  WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50
+  WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59
+  WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68
+  WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77
+  WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86
+  WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95
+  WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102 WLA1_103
+  WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110 WLA1_111
+  WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118 WLA1_119
+  WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126 WLA1_127
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36
+  WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45
+  WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54
+  WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63
+  WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72
+  WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81
+  WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90
+  WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99
+  WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107
+  WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115
+  WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123
+  WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4
+  WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14
+  WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23
+  WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32
+  WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41
+  WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50
+  WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59
+  WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68
+  WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77
+  WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86
+  WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95
+  WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119
+  WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127
+  RAMTP1024X16CORE_COLXR
XLEFTBOT_IO BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0 BLA2_1 BLA2_2
+  BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2 BLA3_3 BLA3_4
+  BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB2_0
+  BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0 BLB3_1 BLB3_2
+  BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 SI DWLA D_7 D_6 D_5 D_4 D_3 D_2 D_1 D_0
+  NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0
+  NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1
+  NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2
+  NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3
+  NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4
+  NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5
+  NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6
+  NBLB3_7 NSAE NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB Q_7 Q_6 Q_5
+  Q_4 Q_3 Q_2 Q_1 Q_0 SAPRECH SI SI TIELO_1 VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE_540 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDPE VDDCE VSSE VSSE VSSE WCLK WEN_7 WEN_6 WEN_5 WEN_4 WEN_3 WEN_2 WEN_1
+  WEN_0 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2
+  YPCOLCLK3 RAMTP1024X16BOT_IO_LT
XRIGHTBOT_IO BLA0_0_883 BLA0_2_851 BLA0_4_819 BLA0_6_787 BLA0_8 BLA0_10
+  BLA0_12 BLA0_14 BLA1_0_873 BLA1_2_841 BLA1_4_809 BLA1_6_777 BLA1_8 BLA1_10
+  BLA1_12 BLA1_14 BLA0_1_867 BLA0_3_835 BLA0_5_803 BLA0_7_771 BLA0_9 BLA0_11
+  BLA0_13 BLA0_15 BLA1_1_857 BLA1_3_825 BLA1_5_793 BLA1_7_761 BLA1_9 BLA1_11
+  BLA1_13 BLA1_15 BLB0_0_879 BLB0_2_847 BLB0_4_815 BLB0_6_783 BLB0_8 BLB0_10
+  BLB0_12 BLB0_14 BLB1_0_877 BLB1_2_845 BLB1_4_813 BLB1_6_781 BLB1_8 BLB1_10
+  BLB1_12 BLB1_14 BLB0_1_863 BLB0_3_831 BLB0_5_799 BLB0_7_767 BLB0_9 BLB0_11
+  BLB0_13 BLB0_15 BLB1_1_861 BLB1_3_829 BLB1_5_797 BLB1_7_765 BLB1_9 BLB1_11
+  BLB1_13 BLB1_15 SI DWLB D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 NBLA0_0_885
+  NBLA0_2_853 NBLA0_4_821 NBLA0_6_789 NBLA0_8 NBLA0_10 NBLA0_12 NBLA0_14
+  NBLA1_0_871 NBLA1_2_839 NBLA1_4_807 NBLA1_6_775 NBLA1_8 NBLA1_10 NBLA1_12
+  NBLA1_14 NBLA0_1_869 NBLA0_3_837 NBLA0_5_805 NBLA0_7_773 NBLA0_9 NBLA0_11
+  NBLA0_13 NBLA0_15 NBLA1_1_855 NBLA1_3_823 NBLA1_5_791 NBLA1_7_759 NBLA1_9
+  NBLA1_11 NBLA1_13 NBLA1_15 NBLB0_0_881 NBLB0_2_849 NBLB0_4_817 NBLB0_6_785
+  NBLB0_8 NBLB0_10 NBLB0_12 NBLB0_14 NBLB1_0_875 NBLB1_2_843 NBLB1_4_811
+  NBLB1_6_779 NBLB1_8 NBLB1_10 NBLB1_12 NBLB1_14 NBLB0_1_865 NBLB0_3_833
+  NBLB0_5_801 NBLB0_7_769 NBLB0_9 NBLB0_11 NBLB0_13 NBLB0_15 NBLB1_1_859
+  NBLB1_3_827 NBLB1_5_795 NBLB1_7_763 NBLB1_9 NBLB1_11 NBLB1_13 NBLB1_15 NSAE
+  NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA_R PRECHB_R Q_8 Q_9 Q_10 Q_11
+  Q_12 Q_13 Q_14 Q_15 SAPRECH TIELOFPB TIELOFPB TIELOCDB VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE_689 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDPE VDDCE VSSE VSSE VSSE WCLK WEN_7 WEN_8 WEN_9 WEN_10 WEN_11
+  WEN_12 WEN_13 WEN_14 WEN_15 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0
+  YPCOLCLK1 YPCOLCLK2 YPCOLCLK3 RAMTP1024X16BOT_IO_RT
XWD_STACKCAP DBLA_OUT DBLB DWLA DWLB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA1
+  GTPA1 GTPB0 GTPB0 LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A
+  LOG1B RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RETA RETB VDDCE VDDPE VSSE WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4
+  WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14
+  WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23
+  WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32
+  WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41
+  WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50
+  WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59
+  WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68
+  WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77
+  WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86
+  WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95
+  WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103
+  WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111
+  WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119
+  WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127
+  WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63
+  WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72
+  WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81
+  WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90
+  WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99
+  WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107
+  WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115
+  WLA1_116 WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123
+  WLA1_124 WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4
+  WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14
+  WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23
+  WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32
+  WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41
+  WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50
+  WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59
+  WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68
+  WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77
+  WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86
+  WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95
+  WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103
+  WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111
+  WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119
+  WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127
+  WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36
+  WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45
+  WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54
+  WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63
+  WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72
+  WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81
+  WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90
+  WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99
+  WLB1_100 WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107
+  WLB1_108 WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115
+  WLB1_116 WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123
+  WLB1_124 WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16WD_STACKCAP
.ENDS RAMTP1024X16TTOP
****
.SUBCKT RAMTP1024X16 VDDCE VDDPE VSSE QA[15] QA[14] QA[13] QA[12] QA[11]
+  QA[10] QA[9] QA[8] QA[7] QA[6] QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] CLKA
+  CENA AA[9] AA[8] AA[7] AA[6] AA[5] AA[4] AA[3] AA[2] AA[1] AA[0] CLKB CENB
+  WENB[15] WENB[14] WENB[13] WENB[12] WENB[11] WENB[10] WENB[9] WENB[8]
+  WENB[7] WENB[6] WENB[5] WENB[4] WENB[3] WENB[2] WENB[1] WENB[0] AB[9] AB[8]
+  AB[7] AB[6] AB[5] AB[4] AB[3] AB[2] AB[1] AB[0] DB[15] DB[14] DB[13] DB[12]
+  DB[11] DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2] DB[1] DB[0]
+  EMAA[2] EMAA[1] EMAA[0] EMAB[2] EMAB[1] EMAB[0] RET1N COLLDISN
** RAMTP1024X16: 143099 flat devices **
XI0 AA[0] AA[1] AB[0] AB[1] CENA CENB CLKA CLKB COLLDISN DB[0] DB[1] DB[2]
+  DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12] DB[13]
+  DB[14] DB[15] EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] AA[2] AA[3]
+  AB[2] AB[3] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9]
+  QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] AA[4] AA[5] AA[6] AA[7] AA[8]
+  AA[9] AB[4] AB[5] AB[6] AB[7] AB[8] AB[9] RET1N VDDCE VDDPE VSSE WENB[0]
+  WENB[1] WENB[2] WENB[3] WENB[4] WENB[5] WENB[6] WENB[7] WENB[8] WENB[9]
+  WENB[10] WENB[11] WENB[12] WENB[13] WENB[14] WENB[15] RAMTP1024X16TTOP
.ENDS RAMTP1024X16
