* 
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Two Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.589um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 16 -b\
* Configuration: mux off -bus_notation on -check_instname on -diode\
* Configuration: s on -drive 6 -ema on -frequency 1.0 -instname RAM\
* Configuration: TP1024X16 -left_bus_delim "[" -mux 4 -mvt "" -name\
* Configuration: _case upper -power_type otc -prefix "" -pwr_gnd_re\
* Configuration: name vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention \
* Configuration: on -right_bus_delim "]" -ser none -site_def off -t\
* Configuration: op_layer m5-m10 -words 1024 -write_mask on -corner\
* Configuration: s ff_1p10v_1p10v_0c,ff_1p10v_1p10v_125c,ff_1p10v_1\
* Configuration: p10v_m40c,ff_1p21v_1p21v_0c,ff_1p21v_1p21v_125c,ff\
* Configuration: _1p21v_1p21v_m40c,ff_1p26v_1p26v_0c,ff_1p26v_1p26v\
* Configuration: _125c,ff_1p26v_1p26v_85c,ff_1p26v_1p26v_m40c,ss_0p\
* Configuration: 90v_0p90v_0c,ss_0p90v_0p90v_125c,ss_0p90v_0p90v_m4\
* Configuration: 0c,ss_0p99v_0p99v_0c,ss_0p99v_0p99v_125c,ss_0p99v_\
* Configuration: 0p99v_m40c,ss_1p08v_1p08v_0c,ss_1p08v_1p08v_125c,s\
* Configuration: s_1p08v_1p08v_m40c,tt_1p00v_1p00v_125c,tt_1p00v_1p\
* Configuration: 00v_25c,tt_1p00v_1p00v_85c,tt_1p10v_1p10v_125c,tt_\
* Configuration: 1p10v_1p10v_25c,tt_1p10v_1p10v_85c,tt_1p20v_1p20v_\
* Configuration: 125c,tt_1p20v_1p20v_25c,tt_1p20v_1p20v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RAMTP1024X16WD2X2 DBLA DBLA_DUM0 DBLA_DUM1 DBLB GA0 GA1 GB0 GB1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC NI0A NI0B NI1A
+  NI1B NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6
+  NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7
+  NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0
+  NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 R0A R0B R1A R1B
+  RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC_WLA0 VDDC_WLA1 VDDC_WLB0 VDDC_WLB1 VDDPE VDDP_WDA VDDP_WDB
+  VNWC VNWP VPW VSS VSSE WLA0 WLA1 WLB0 WLB1
** RAMTP1024X16WD2X2: 43 flat devices **
X_MXNpg_wd_dp299_dbla_dum1 DBLA_DUM1 LOG0_DWLA VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_wd_base.I8.MX_npd _WD_BASE.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base.I8._nr.MXNA1 _WD_BASE.ROWSELA GA0 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8._nr.MXNA2 _WD_BASE.ROWSELA GA1 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8._nr.MXPA1 _WD_BASE.ROWSELA GA0 _WD_BASE.I8._NR.P1 VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base.I8._nr.MXPA2 _WD_BASE.I8._NR.P1 GA1 VDDP_WDA VNWP P11LL_CKT
+  W=1.135U L=0.04U
X_M_wd_base.I9.MX_npd _WD_BASE.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base.I9._nr.MXNA1 _WD_BASE.ROWSELB GB0 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9._nr.MXNA2 _WD_BASE.ROWSELB GB1 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9._nr.MXPA1 _WD_BASE.ROWSELB GB0 _WD_BASE.I9._NR.P1 VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base.I9._nr.MXPA2 _WD_BASE.I9._NR.P1 GB1 VDDP_WDB VNWP P11LL_CKT
+  W=1.135U L=0.04U
X_M_wd_base._drvwla0.MXN10 NI0A R0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwla0.MXN11 WLA0 _WD_BASE._DRVWLA0.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwla0.MXN8 _WD_BASE._DRVWLA0.NWL _WD_BASE.ROWSELA NI0A VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwla0.MXP12 _WD_BASE._DRVWLA0.NWL R0A VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwla0.MXP13 _WD_BASE._DRVWLA0.NWL _WD_BASE.ROWSELA VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwla0.MXP7 WLA0 _WD_BASE._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwla1.MXN10 NI1A R1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwla1.MXN11 WLA1 _WD_BASE._DRVWLA1.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwla1.MXN8 _WD_BASE._DRVWLA1.NWL _WD_BASE.ROWSELA NI1A VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwla1.MXP12 _WD_BASE._DRVWLA1.NWL R1A VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwla1.MXP13 _WD_BASE._DRVWLA1.NWL _WD_BASE.ROWSELA VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwla1.MXP7 WLA1 _WD_BASE._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwlb0.MXN10 NI0B R0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwlb0.MXN11 WLB0 _WD_BASE._DRVWLB0.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwlb0.MXN8 _WD_BASE._DRVWLB0.NWL _WD_BASE.ROWSELB NI0B VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwlb0.MXP12 _WD_BASE._DRVWLB0.NWL R0B VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwlb0.MXP13 _WD_BASE._DRVWLB0.NWL _WD_BASE.ROWSELB VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwlb0.MXP7 WLB0 _WD_BASE._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwlb1.MXN10 NI1B R1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwlb1.MXN11 WLB1 _WD_BASE._DRVWLB1.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwlb1.MXN8 _WD_BASE._DRVWLB1.NWL _WD_BASE.ROWSELB NI1B VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwlb1.MXP12 _WD_BASE._DRVWLB1.NWL R1B VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwlb1.MXP13 _WD_BASE._DRVWLB1.NWL _WD_BASE.ROWSELB VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwlb1.MXP7 WLB1 _WD_BASE._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_dp299_dbla.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_wd_dp299_dbla.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_wd_dp299_dbla_dum0.MXNpg_0 DBLA_DUM0 LOG0_DWLA VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_wd_dp299_dbla_dum0.MXNpg_1 DBLA_DUM0 LOG0_DWLA VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_wd_dp299_dblb.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.45U L=0.04U
X_M_wd_dp299_dblb.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.45U L=0.04U
.ENDS RAMTP1024X16WD2X2
****
.SUBCKT RAMTP1024X16WD32X2 DBLA DBLA_DUMO DBLA_OUT DBLA_UP DBLB DWLA DWLB
+  EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1
+  LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A LOG1B N0A N0B N1A N1B
+  N2A N2B N3A N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4
+  NXAP0_5 NXAP0_6 NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5
+  NXAP1_6 NXAP1_7 NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6
+  NXBP0_7 NXBP1_0 NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7
+  RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A
+  ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0
+  VDDC_FDECA1 VDDC_FDECB0 VDDC_FDECB1 VDDC_WLA0 VDDC_WLA1 VDDC_WLB0 VDDC_WLB1
+  VDDPE VDDP_WDA VDDP_WDB VNWC VNWP VPW VSS VSSE WLA0 WLA1 WLA2 WLA3 WLA4
+  WLA5 WLA6 WLA7 WLA8 WLA9 WLA10 WLA11 WLA12 WLA13 WLA14 WLA15 WLA16 WLA17
+  WLA18 WLA19 WLA20 WLA21 WLA22 WLA23 WLA24 WLA25 WLA26 WLA27 WLA28 WLA29
+  WLA30 WLA31 WLB0 WLB1 WLB2 WLB3 WLB4 WLB5 WLB6 WLB7 WLB8 WLB9 WLB10 WLB11
+  WLB12 WLB13 WLB14 WLB15 WLB16 WLB17 WLB18 WLB19 WLB20 WLB21 WLB22 WLB23
+  WLB24 WLB25 WLB26 WLB27 WLB28 WLB29 WLB30 WLB31
** RAMTP1024X16WD32X2: 1211 flat devices **
X_MI1.I8.MX_npd I1.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI1.I8._nr.MXNA1 I1.ROWSELA NXAP0_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8._nr.MXNA2 I1.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8._nr.MXPA1 I1.ROWSELA NXAP0_0 I1.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I8._nr.MXPA2 I1.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I9.MX_npd I1.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI1.I9._nr.MXNA1 I1.ROWSELB NXBP0_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9._nr.MXNA2 I1.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9._nr.MXPA1 I1.ROWSELB NXBP0_0 I1.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I9._nr.MXPA2 I1.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwla0.MXN11 WLA2 I1._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwla0.MXN8 I1._DRVWLA0.NWL I1.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwla0.MXP12 I1._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwla0.MXP13 I1._DRVWLA0.NWL I1.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwla0.MXP7 WLA2 I1._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwla1.MXN11 WLA3 I1._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwla1.MXN8 I1._DRVWLA1.NWL I1.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwla1.MXP12 I1._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwla1.MXP13 I1._DRVWLA1.NWL I1.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwla1.MXP7 WLA3 I1._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwlb0.MXN11 WLB2 I1._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwlb0.MXN8 I1._DRVWLB0.NWL I1.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwlb0.MXP12 I1._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwlb0.MXP13 I1._DRVWLB0.NWL I1.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwlb0.MXP7 WLB2 I1._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwlb1.MXN11 WLB3 I1._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwlb1.MXN8 I1._DRVWLB1.NWL I1.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwlb1.MXP12 I1._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwlb1.MXP13 I1._DRVWLB1.NWL I1.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwlb1.MXP7 WLB3 I1._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI2.I8.MX_npd I2.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI2.I8._nr.MXNA1 I2.ROWSELA NXAP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8._nr.MXNA2 I2.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8._nr.MXPA1 I2.ROWSELA NXAP0_1 I2.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I8._nr.MXPA2 I2.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I9.MX_npd I2.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI2.I9._nr.MXNA1 I2.ROWSELB NXBP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9._nr.MXNA2 I2.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9._nr.MXPA1 I2.ROWSELB NXBP0_1 I2.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I9._nr.MXPA2 I2.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwla0.MXN11 WLA4 I2._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwla0.MXN8 I2._DRVWLA0.NWL I2.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwla0.MXP12 I2._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwla0.MXP13 I2._DRVWLA0.NWL I2.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwla0.MXP7 WLA4 I2._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwla1.MXN11 WLA5 I2._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwla1.MXN8 I2._DRVWLA1.NWL I2.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwla1.MXP12 I2._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwla1.MXP13 I2._DRVWLA1.NWL I2.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwla1.MXP7 WLA5 I2._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwlb0.MXN11 WLB4 I2._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwlb0.MXN8 I2._DRVWLB0.NWL I2.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwlb0.MXP12 I2._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwlb0.MXP13 I2._DRVWLB0.NWL I2.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwlb0.MXP7 WLB4 I2._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwlb1.MXN11 WLB5 I2._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwlb1.MXN8 I2._DRVWLB1.NWL I2.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwlb1.MXP12 I2._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwlb1.MXP13 I2._DRVWLB1.NWL I2.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwlb1.MXP7 WLB5 I2._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI20_0.MXNA1 ILAA[0] NLAA[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI20_0.MXPA1 ILAA[0] NLAA[0] VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_MI20_1.MXNA1 ILAA[1] NLAA[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI20_1.MXPA1 ILAA[1] NLAA[1] VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_MI21_0.MXNA1 IRAA[0] NRAA[0] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_0.MXPA1 IRAA[0] NRAA[0] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI21_1.MXNA1 IRAA[1] NRAA[1] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_1.MXPA1 IRAA[1] NRAA[1] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI21_2.MXNA1 IRAA[2] NRAA[2] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_2.MXPA1 IRAA[2] NRAA[2] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI22_0.MXNA1 NRAA[0] RAA[0] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_0.MXPA1 NRAA[0] RAA[0] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI22_1.MXNA1 NRAA[1] RAA[1] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_1.MXPA1 NRAA[1] RAA[1] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI22_2.MXNA1 NRAA[2] RAA[2] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_2.MXPA1 NRAA[2] RAA[2] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_0.MXNA1 NRAA[3] RAA[3] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_0.MXPA1 NRAA[3] RAA[3] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_1.MXNA1 NRAA[4] RAA[4] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_1.MXPA1 NRAA[4] RAA[4] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_2.MXNA1 NRAA[5] RAA[5] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_2.MXPA1 NRAA[5] RAA[5] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI24_0.MXNA1 IRAA[3] NRAA[3] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_0.MXPA1 IRAA[3] NRAA[3] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI24_1.MXNA1 IRAA[4] NRAA[4] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_1.MXPA1 IRAA[4] NRAA[4] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI24_2.MXNA1 IRAA[5] NRAA[5] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_2.MXPA1 IRAA[5] NRAA[5] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_0.MXNA1 IRAB[3] NRAB[3] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_0.MXPA1 IRAB[3] NRAB[3] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_1.MXNA1 IRAB[4] NRAB[4] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_1.MXPA1 IRAB[4] NRAB[4] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_2.MXNA1 IRAB[5] NRAB[5] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_2.MXPA1 IRAB[5] NRAB[5] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI26_0.MXNA1 NRAB[3] RAB[3] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_0.MXPA1 NRAB[3] RAB[3] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI26_1.MXNA1 NRAB[4] RAB[4] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_1.MXPA1 NRAB[4] RAB[4] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI26_2.MXNA1 NRAB[5] RAB[5] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_2.MXPA1 NRAB[5] RAB[5] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_0.MXNA1 NRAB[0] RAB[0] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_0.MXPA1 NRAB[0] RAB[0] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_1.MXNA1 NRAB[1] RAB[1] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_1.MXPA1 NRAB[1] RAB[1] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_2.MXNA1 NRAB[2] RAB[2] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_2.MXPA1 NRAB[2] RAB[2] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI28_0.MXNA1 IRAB[0] NRAB[0] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_0.MXPA1 IRAB[0] NRAB[0] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI28_1.MXNA1 IRAB[1] NRAB[1] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_1.MXPA1 IRAB[1] NRAB[1] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI28_2.MXNA1 IRAB[2] NRAB[2] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_2.MXPA1 IRAB[2] NRAB[2] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI29_0.MXNA1 ILAB[0] NLAB[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI29_0.MXPA1 ILAB[0] NLAB[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI29_1.MXNA1 ILAB[1] NLAB[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI29_1.MXPA1 ILAB[1] NLAB[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI3.I8.MX_npd I3.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI3.I8._nr.MXNA1 I3.ROWSELA NXAP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8._nr.MXNA2 I3.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8._nr.MXPA1 I3.ROWSELA NXAP0_1 I3.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I8._nr.MXPA2 I3.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I9.MX_npd I3.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI3.I9._nr.MXNA1 I3.ROWSELB NXBP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9._nr.MXNA2 I3.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9._nr.MXPA1 I3.ROWSELB NXBP0_1 I3.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I9._nr.MXPA2 I3.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwla0.MXN11 WLA6 I3._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwla0.MXN8 I3._DRVWLA0.NWL I3.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwla0.MXP12 I3._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwla0.MXP13 I3._DRVWLA0.NWL I3.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwla0.MXP7 WLA6 I3._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwla1.MXN11 WLA7 I3._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwla1.MXN8 I3._DRVWLA1.NWL I3.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwla1.MXP12 I3._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwla1.MXP13 I3._DRVWLA1.NWL I3.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwla1.MXP7 WLA7 I3._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwlb0.MXN11 WLB6 I3._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwlb0.MXN8 I3._DRVWLB0.NWL I3.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwlb0.MXP12 I3._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwlb0.MXP13 I3._DRVWLB0.NWL I3.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwlb0.MXP7 WLB6 I3._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwlb1.MXN11 WLB7 I3._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwlb1.MXN8 I3._DRVWLB1.NWL I3.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwlb1.MXP12 I3._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwlb1.MXP13 I3._DRVWLB1.NWL I3.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwlb1.MXP7 WLB7 I3._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI30_0.MXNA1 NLAB[0] LAB[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI30_0.MXPA1 NLAB[0] LAB[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI30_1.MXNA1 NLAB[1] LAB[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI30_1.MXPA1 NLAB[1] LAB[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI35.I8.MX_npd I35.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI35.I8._nr.MXNA1 I35.ROWSELA NXAP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8._nr.MXNA2 I35.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8._nr.MXPA1 I35.ROWSELA NXAP0_4 I35.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I8._nr.MXPA2 I35.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I9.MX_npd I35.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI35.I9._nr.MXNA1 I35.ROWSELB NXBP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9._nr.MXNA2 I35.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9._nr.MXPA1 I35.ROWSELB NXBP0_4 I35.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I9._nr.MXPA2 I35.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwla0.MXN11 WLA16 I35._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwla0.MXN8 I35._DRVWLA0.NWL I35.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwla0.MXP12 I35._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwla0.MXP13 I35._DRVWLA0.NWL I35.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwla0.MXP7 WLA16 I35._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwla1.MXN11 WLA17 I35._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwla1.MXN8 I35._DRVWLA1.NWL I35.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwla1.MXP12 I35._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwla1.MXP13 I35._DRVWLA1.NWL I35.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwla1.MXP7 WLA17 I35._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwlb0.MXN11 WLB16 I35._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwlb0.MXN8 I35._DRVWLB0.NWL I35.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwlb0.MXP12 I35._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwlb0.MXP13 I35._DRVWLB0.NWL I35.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwlb0.MXP7 WLB16 I35._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwlb1.MXN11 WLB17 I35._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwlb1.MXN8 I35._DRVWLB1.NWL I35.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwlb1.MXP12 I35._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwlb1.MXP13 I35._DRVWLB1.NWL I35.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwlb1.MXP7 WLB17 I35._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36.I8.MX_npd I36.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI36.I8._nr.MXNA1 I36.ROWSELA NXAP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8._nr.MXNA2 I36.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8._nr.MXPA1 I36.ROWSELA NXAP0_4 I36.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I8._nr.MXPA2 I36.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I9.MX_npd I36.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI36.I9._nr.MXNA1 I36.ROWSELB NXBP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9._nr.MXNA2 I36.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9._nr.MXPA1 I36.ROWSELB NXBP0_4 I36.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I9._nr.MXPA2 I36.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwla0.MXN11 WLA18 I36._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwla0.MXN8 I36._DRVWLA0.NWL I36.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwla0.MXP12 I36._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwla0.MXP13 I36._DRVWLA0.NWL I36.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwla0.MXP7 WLA18 I36._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwla1.MXN11 WLA19 I36._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwla1.MXN8 I36._DRVWLA1.NWL I36.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwla1.MXP12 I36._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwla1.MXP13 I36._DRVWLA1.NWL I36.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwla1.MXP7 WLA19 I36._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwlb0.MXN11 WLB18 I36._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwlb0.MXN8 I36._DRVWLB0.NWL I36.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwlb0.MXP12 I36._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwlb0.MXP13 I36._DRVWLB0.NWL I36.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwlb0.MXP7 WLB18 I36._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwlb1.MXN11 WLB19 I36._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwlb1.MXN8 I36._DRVWLB1.NWL I36.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwlb1.MXP12 I36._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwlb1.MXP13 I36._DRVWLB1.NWL I36.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwlb1.MXP7 WLB19 I36._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI4.I8.MX_npd I4.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI4.I8._nr.MXNA1 I4.ROWSELA NXAP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8._nr.MXNA2 I4.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8._nr.MXPA1 I4.ROWSELA NXAP0_2 I4.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I8._nr.MXPA2 I4.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I9.MX_npd I4.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI4.I9._nr.MXNA1 I4.ROWSELB NXBP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9._nr.MXNA2 I4.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9._nr.MXPA1 I4.ROWSELB NXBP0_2 I4.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I9._nr.MXPA2 I4.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwla0.MXN11 WLA8 I4._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwla0.MXN8 I4._DRVWLA0.NWL I4.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwla0.MXP12 I4._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwla0.MXP13 I4._DRVWLA0.NWL I4.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwla0.MXP7 WLA8 I4._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwla1.MXN11 WLA9 I4._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwla1.MXN8 I4._DRVWLA1.NWL I4.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwla1.MXP12 I4._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwla1.MXP13 I4._DRVWLA1.NWL I4.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwla1.MXP7 WLA9 I4._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwlb0.MXN11 WLB8 I4._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwlb0.MXN8 I4._DRVWLB0.NWL I4.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwlb0.MXP12 I4._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwlb0.MXP13 I4._DRVWLB0.NWL I4.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwlb0.MXP7 WLB8 I4._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwlb1.MXN11 WLB9 I4._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwlb1.MXN8 I4._DRVWLB1.NWL I4.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwlb1.MXP12 I4._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwlb1.MXP13 I4._DRVWLB1.NWL I4.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwlb1.MXP7 WLB9 I4._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI40.I8.MX_npd I40.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI40.I8._nr.MXNA1 I40.ROWSELA NXAP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8._nr.MXNA2 I40.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8._nr.MXPA1 I40.ROWSELA NXAP0_5 I40.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I8._nr.MXPA2 I40.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I9.MX_npd I40.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI40.I9._nr.MXNA1 I40.ROWSELB NXBP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9._nr.MXNA2 I40.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9._nr.MXPA1 I40.ROWSELB NXBP0_5 I40.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I9._nr.MXPA2 I40.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwla0.MXN11 WLA20 I40._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwla0.MXN8 I40._DRVWLA0.NWL I40.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwla0.MXP12 I40._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwla0.MXP13 I40._DRVWLA0.NWL I40.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwla0.MXP7 WLA20 I40._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwla1.MXN11 WLA21 I40._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwla1.MXN8 I40._DRVWLA1.NWL I40.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwla1.MXP12 I40._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwla1.MXP13 I40._DRVWLA1.NWL I40.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwla1.MXP7 WLA21 I40._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwlb0.MXN11 WLB20 I40._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwlb0.MXN8 I40._DRVWLB0.NWL I40.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwlb0.MXP12 I40._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwlb0.MXP13 I40._DRVWLB0.NWL I40.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwlb0.MXP7 WLB20 I40._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwlb1.MXN11 WLB21 I40._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwlb1.MXN8 I40._DRVWLB1.NWL I40.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwlb1.MXP12 I40._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwlb1.MXP13 I40._DRVWLB1.NWL I40.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwlb1.MXP7 WLB21 I40._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42.I8.MX_npd I42.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI42.I8._nr.MXNA1 I42.ROWSELA NXAP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8._nr.MXNA2 I42.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8._nr.MXPA1 I42.ROWSELA NXAP0_5 I42.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I8._nr.MXPA2 I42.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I9.MX_npd I42.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI42.I9._nr.MXNA1 I42.ROWSELB NXBP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9._nr.MXNA2 I42.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9._nr.MXPA1 I42.ROWSELB NXBP0_5 I42.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I9._nr.MXPA2 I42.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwla0.MXN11 WLA22 I42._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwla0.MXN8 I42._DRVWLA0.NWL I42.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwla0.MXP12 I42._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwla0.MXP13 I42._DRVWLA0.NWL I42.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwla0.MXP7 WLA22 I42._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwla1.MXN11 WLA23 I42._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwla1.MXN8 I42._DRVWLA1.NWL I42.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwla1.MXP12 I42._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwla1.MXP13 I42._DRVWLA1.NWL I42.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwla1.MXP7 WLA23 I42._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwlb0.MXN11 WLB22 I42._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwlb0.MXN8 I42._DRVWLB0.NWL I42.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwlb0.MXP12 I42._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwlb0.MXP13 I42._DRVWLB0.NWL I42.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwlb0.MXP7 WLB22 I42._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwlb1.MXN11 WLB23 I42._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwlb1.MXN8 I42._DRVWLB1.NWL I42.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwlb1.MXP12 I42._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwlb1.MXP13 I42._DRVWLB1.NWL I42.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwlb1.MXP7 WLB23 I42._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43.I8.MX_npd I43.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI43.I8._nr.MXNA1 I43.ROWSELA NXAP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8._nr.MXNA2 I43.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8._nr.MXPA1 I43.ROWSELA NXAP0_6 I43.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I8._nr.MXPA2 I43.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I9.MX_npd I43.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI43.I9._nr.MXNA1 I43.ROWSELB NXBP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9._nr.MXNA2 I43.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9._nr.MXPA1 I43.ROWSELB NXBP0_6 I43.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I9._nr.MXPA2 I43.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwla0.MXN11 WLA24 I43._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwla0.MXN8 I43._DRVWLA0.NWL I43.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwla0.MXP12 I43._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwla0.MXP13 I43._DRVWLA0.NWL I43.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwla0.MXP7 WLA24 I43._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwla1.MXN11 WLA25 I43._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwla1.MXN8 I43._DRVWLA1.NWL I43.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwla1.MXP12 I43._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwla1.MXP13 I43._DRVWLA1.NWL I43.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwla1.MXP7 WLA25 I43._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwlb0.MXN11 WLB24 I43._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwlb0.MXN8 I43._DRVWLB0.NWL I43.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwlb0.MXP12 I43._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwlb0.MXP13 I43._DRVWLB0.NWL I43.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwlb0.MXP7 WLB24 I43._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwlb1.MXN11 WLB25 I43._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwlb1.MXN8 I43._DRVWLB1.NWL I43.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwlb1.MXP12 I43._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwlb1.MXP13 I43._DRVWLB1.NWL I43.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwlb1.MXP7 WLB25 I43._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44.I8.MX_npd I44.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI44.I8._nr.MXNA1 I44.ROWSELA NXAP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8._nr.MXNA2 I44.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8._nr.MXPA1 I44.ROWSELA NXAP0_6 I44.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I8._nr.MXPA2 I44.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I9.MX_npd I44.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI44.I9._nr.MXNA1 I44.ROWSELB NXBP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9._nr.MXNA2 I44.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9._nr.MXPA1 I44.ROWSELB NXBP0_6 I44.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I9._nr.MXPA2 I44.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwla0.MXN11 WLA26 I44._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwla0.MXN8 I44._DRVWLA0.NWL I44.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwla0.MXP12 I44._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwla0.MXP13 I44._DRVWLA0.NWL I44.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwla0.MXP7 WLA26 I44._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwla1.MXN11 WLA27 I44._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwla1.MXN8 I44._DRVWLA1.NWL I44.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwla1.MXP12 I44._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwla1.MXP13 I44._DRVWLA1.NWL I44.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwla1.MXP7 WLA27 I44._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwlb0.MXN11 WLB26 I44._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwlb0.MXN8 I44._DRVWLB0.NWL I44.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwlb0.MXP12 I44._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwlb0.MXP13 I44._DRVWLB0.NWL I44.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwlb0.MXP7 WLB26 I44._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwlb1.MXN11 WLB27 I44._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwlb1.MXN8 I44._DRVWLB1.NWL I44.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwlb1.MXP12 I44._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwlb1.MXP13 I44._DRVWLB1.NWL I44.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwlb1.MXP7 WLB27 I44._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45.I8.MX_npd I45.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI45.I8._nr.MXNA1 I45.ROWSELA NXAP0_7 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8._nr.MXNA2 I45.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8._nr.MXPA1 I45.ROWSELA NXAP0_7 I45.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I8._nr.MXPA2 I45.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I9.MX_npd I45.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI45.I9._nr.MXNA1 I45.ROWSELB NXBP0_7 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9._nr.MXNA2 I45.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9._nr.MXPA1 I45.ROWSELB NXBP0_7 I45.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I9._nr.MXPA2 I45.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwla0.MXN11 WLA28 I45._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwla0.MXN8 I45._DRVWLA0.NWL I45.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwla0.MXP12 I45._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwla0.MXP13 I45._DRVWLA0.NWL I45.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwla0.MXP7 WLA28 I45._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwla1.MXN11 WLA29 I45._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwla1.MXN8 I45._DRVWLA1.NWL I45.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwla1.MXP12 I45._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwla1.MXP13 I45._DRVWLA1.NWL I45.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwla1.MXP7 WLA29 I45._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwlb0.MXN11 WLB28 I45._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwlb0.MXN8 I45._DRVWLB0.NWL I45.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwlb0.MXP12 I45._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwlb0.MXP13 I45._DRVWLB0.NWL I45.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwlb0.MXP7 WLB28 I45._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwlb1.MXN11 WLB29 I45._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwlb1.MXN8 I45._DRVWLB1.NWL I45.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwlb1.MXP12 I45._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwlb1.MXP13 I45._DRVWLB1.NWL I45.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwlb1.MXP7 WLB29 I45._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5.I8.MX_npd I5.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI5.I8._nr.MXNA1 I5.ROWSELA NXAP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8._nr.MXNA2 I5.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8._nr.MXPA1 I5.ROWSELA NXAP0_2 I5.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I8._nr.MXPA2 I5.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I9.MX_npd I5.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI5.I9._nr.MXNA1 I5.ROWSELB NXBP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9._nr.MXNA2 I5.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9._nr.MXPA1 I5.ROWSELB NXBP0_2 I5.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I9._nr.MXPA2 I5.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwla0.MXN11 WLA10 I5._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwla0.MXN8 I5._DRVWLA0.NWL I5.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwla0.MXP12 I5._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwla0.MXP13 I5._DRVWLA0.NWL I5.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwla0.MXP7 WLA10 I5._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwla1.MXN11 WLA11 I5._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwla1.MXN8 I5._DRVWLA1.NWL I5.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwla1.MXP12 I5._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwla1.MXP13 I5._DRVWLA1.NWL I5.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwla1.MXP7 WLA11 I5._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwlb0.MXN11 WLB10 I5._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwlb0.MXN8 I5._DRVWLB0.NWL I5.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwlb0.MXP12 I5._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwlb0.MXP13 I5._DRVWLB0.NWL I5.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwlb0.MXP7 WLB10 I5._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwlb1.MXN11 WLB11 I5._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwlb1.MXN8 I5._DRVWLB1.NWL I5.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwlb1.MXP12 I5._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwlb1.MXP13 I5._DRVWLB1.NWL I5.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwlb1.MXP7 WLB11 I5._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6.I8.MX_npd I6.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI6.I8._nr.MXNA1 I6.ROWSELA NXAP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8._nr.MXNA2 I6.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8._nr.MXPA1 I6.ROWSELA NXAP0_3 I6.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I8._nr.MXPA2 I6.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I9.MX_npd I6.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI6.I9._nr.MXNA1 I6.ROWSELB NXBP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9._nr.MXNA2 I6.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9._nr.MXPA1 I6.ROWSELB NXBP0_3 I6.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I9._nr.MXPA2 I6.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwla0.MXN11 WLA12 I6._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwla0.MXN8 I6._DRVWLA0.NWL I6.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwla0.MXP12 I6._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwla0.MXP13 I6._DRVWLA0.NWL I6.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwla0.MXP7 WLA12 I6._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwla1.MXN11 WLA13 I6._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwla1.MXN8 I6._DRVWLA1.NWL I6.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwla1.MXP12 I6._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwla1.MXP13 I6._DRVWLA1.NWL I6.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwla1.MXP7 WLA13 I6._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwlb0.MXN11 WLB12 I6._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwlb0.MXN8 I6._DRVWLB0.NWL I6.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwlb0.MXP12 I6._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwlb0.MXP13 I6._DRVWLB0.NWL I6.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwlb0.MXP7 WLB12 I6._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwlb1.MXN11 WLB13 I6._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwlb1.MXN8 I6._DRVWLB1.NWL I6.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwlb1.MXP12 I6._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwlb1.MXP13 I6._DRVWLB1.NWL I6.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwlb1.MXP7 WLB13 I6._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI69.MXN3 VSSE DBLA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXN4 NET510 I69.NDI VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXN8 I69.NDI DBLA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXP0 I69.NDI DBLA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI69.MXP1 NET510 I69.NDI VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI69.MXP2 NET510 I69.NDI VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI7.I8.MX_npd I7.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI7.I8._nr.MXNA1 I7.ROWSELA NXAP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8._nr.MXNA2 I7.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8._nr.MXPA1 I7.ROWSELA NXAP0_3 I7.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I8._nr.MXPA2 I7.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I9.MX_npd I7.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI7.I9._nr.MXNA1 I7.ROWSELB NXBP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9._nr.MXNA2 I7.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9._nr.MXPA1 I7.ROWSELB NXBP0_3 I7.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I9._nr.MXPA2 I7.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwla0.MXN11 WLA14 I7._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwla0.MXN8 I7._DRVWLA0.NWL I7.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwla0.MXP12 I7._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwla0.MXP13 I7._DRVWLA0.NWL I7.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwla0.MXP7 WLA14 I7._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwla1.MXN11 WLA15 I7._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwla1.MXN8 I7._DRVWLA1.NWL I7.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwla1.MXP12 I7._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwla1.MXP13 I7._DRVWLA1.NWL I7.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwla1.MXP7 WLA15 I7._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwlb0.MXN11 WLB14 I7._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwlb0.MXN8 I7._DRVWLB0.NWL I7.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwlb0.MXP12 I7._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwlb0.MXP13 I7._DRVWLB0.NWL I7.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwlb0.MXP7 WLB14 I7._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwlb1.MXN11 WLB15 I7._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwlb1.MXN8 I7._DRVWLB1.NWL I7.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwlb1.MXP12 I7._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwlb1.MXP13 I7._DRVWLB1.NWL I7.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwlb1.MXP7 WLB15 I7._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI70.MXN3 I70.NDI NET510 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI70.MXN4 DBLA_DUMO I70.NDI VSSE VPW N11LL_CKT W=0.62U L=0.04U
X_MI70.MXN8 I70.NDI NET510 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI70.MXP0 I70.NDI NET510 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI70.MXP1 DBLA_DUMO I70.NDI VDDPE VNWP P11LL_CKT W=0.62U L=0.04U
X_MI70.MXP2 DBLA_DUMO I70.NDI VDDPE VNWP P11LL_CKT W=0.62U L=0.04U
X_MXP2 DBLA_UP DWLA VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_dummy_txa_0.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_0.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_1.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_1.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_0.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_0.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_1.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_1.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_lainv_0.MXNA1 NLAA[0] LAA[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_lainv_0.MXPA1 NLAA[0] LAA[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_lainv_1.MXNA1 NLAA[1] LAA[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_lainv_1.MXPA1 NLAA[1] LAA[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_mem_dbla.I2.MXNA1 _MEM_DBLA.NSEL0 EMAA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I2.MXNA2 _MEM_DBLA.NSEL0 EMAA[0] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I2.MXPA1 _MEM_DBLA.NSEL0 EMAA[2] _MEM_DBLA.I2.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.I2.MXPA2 _MEM_DBLA.I2.P1 EMAA[0] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dbla.I73.MXNA1 _MEM_DBLA.NIDBL DBLA VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_M_mem_dbla.I73.MXPA1 _MEM_DBLA.NIDBL DBLA VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dbla.I77.MXNA1 _MEM_DBLA.NSEL1 EMAA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I77.MXNA2 _MEM_DBLA.NSEL1 EMAA[1] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I77.MXPA1 _MEM_DBLA.NSEL1 EMAA[2] _MEM_DBLA.I77.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.I77.MXPA2 _MEM_DBLA.I77.P1 EMAA[1] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dbla.MXN19 DBLA DWLA _MEM_DBLA.IA[0] VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN20 _MEM_DBLA.IA[0] LOG1A VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN21 VSSE LOG1A VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN22 DBLA DWLA _MEM_DBLA.IA[1] VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dbla.MXN23 _MEM_DBLA.IA[1] _MEM_DBLA.NSEL0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_mem_dbla.MXN24 VSSE LOG1A VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dbla.MXN25 DBLA DWLA _MEM_DBLA.IA[2] VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dbla.MXN26 _MEM_DBLA.IA[2] _MEM_DBLA.NSEL1 VSSE VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_mem_dbla.MXN27 VSSE LOG1A VSSE VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dbla.MXN28 DBLA DWLA _MEM_DBLA.IA[3] VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dbla.MXN29 _MEM_DBLA.IA[3] _MEM_DBLA.NSEL1 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dbla.MXN30 VSSE _MEM_DBLA.NSEL0 VSSE VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dbla.MXP10 _MEM_DBLA.NET53 _MEM_DBLA.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.MXP12 DBLA DWLA VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_mem_dbla.MXP7 _MEM_DBLA.NET057 _MEM_DBLA.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.245U L=0.04U
X_M_mem_dbla.MXP8 DBLA LOG1A _MEM_DBLA.NET057 VNWP P11LL_CKT W=0.245U L=0.04U
X_M_mem_dbla.MXP9 DBLA LOG1A _MEM_DBLA.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_mem_dblb.I2.MXNA1 _MEM_DBLB.NSEL0 EMAB[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I2.MXNA2 _MEM_DBLB.NSEL0 EMAB[0] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I2.MXPA1 _MEM_DBLB.NSEL0 EMAB[2] _MEM_DBLB.I2.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.I2.MXPA2 _MEM_DBLB.I2.P1 EMAB[0] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dblb.I73.MXNA1 _MEM_DBLB.NIDBL DBLB VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_M_mem_dblb.I73.MXPA1 _MEM_DBLB.NIDBL DBLB VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dblb.I77.MXNA1 _MEM_DBLB.NSEL1 EMAB[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I77.MXNA2 _MEM_DBLB.NSEL1 EMAB[1] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I77.MXPA1 _MEM_DBLB.NSEL1 EMAB[2] _MEM_DBLB.I77.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.I77.MXPA2 _MEM_DBLB.I77.P1 EMAB[1] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dblb.MXN19 DBLB DWLB _MEM_DBLB.IA[0] VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN20 _MEM_DBLB.IA[0] LOG1B VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN21 VSSE LOG1B VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN22 DBLB DWLB _MEM_DBLB.IA[1] VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dblb.MXN23 _MEM_DBLB.IA[1] _MEM_DBLB.NSEL0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_mem_dblb.MXN24 VSSE LOG1B VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dblb.MXN25 DBLB DWLB _MEM_DBLB.IA[2] VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dblb.MXN26 _MEM_DBLB.IA[2] _MEM_DBLB.NSEL1 VSSE VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_mem_dblb.MXN27 VSSE LOG1B VSSE VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dblb.MXN28 DBLB DWLB _MEM_DBLB.IA[3] VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dblb.MXN29 _MEM_DBLB.IA[3] _MEM_DBLB.NSEL1 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dblb.MXN30 VSSE _MEM_DBLB.NSEL0 VSSE VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dblb.MXP10 _MEM_DBLB.NET53 _MEM_DBLB.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.MXP12 DBLB DWLB VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_mem_dblb.MXP7 _MEM_DBLB.NET057 _MEM_DBLB.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_mem_dblb.MXP8 DBLB LOG1B _MEM_DBLB.NET057 VNWP P11LL_CKT W=0.25U L=0.04U
X_M_mem_dblb.MXP9 DBLB LOG1B _MEM_DBLB.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_rowcka.I0_0.MXNA1 _ROWCKA.NDEC[0] NLAA[0] _ROWCKA.I0_0.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_0.MXNA2 _ROWCKA.I0_0.N1 NLAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_0.MXPA1 _ROWCKA.NDEC[0] NLAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_0.MXPA2 _ROWCKA.NDEC[0] NLAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_1.MXNA1 _ROWCKA.NDEC[1] ILAA[0] _ROWCKA.I0_1.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_1.MXNA2 _ROWCKA.I0_1.N1 NLAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_1.MXPA1 _ROWCKA.NDEC[1] ILAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_1.MXPA2 _ROWCKA.NDEC[1] NLAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_2.MXNA1 _ROWCKA.NDEC[2] NLAA[0] _ROWCKA.I0_2.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_2.MXNA2 _ROWCKA.I0_2.N1 ILAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_2.MXPA1 _ROWCKA.NDEC[2] NLAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_2.MXPA2 _ROWCKA.NDEC[2] ILAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_3.MXNA1 _ROWCKA.NDEC[3] ILAA[0] _ROWCKA.I0_3.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_3.MXNA2 _ROWCKA.I0_3.N1 ILAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_3.MXPA1 _ROWCKA.NDEC[3] ILAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_3.MXPA2 _ROWCKA.NDEC[3] ILAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I1_0.MXNA1 ROWEN0A _ROWCKA.NDEC[0] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_0.MXPA1 ROWEN0A _ROWCKA.NDEC[0] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_1.MXNA1 ROWEN1A _ROWCKA.NDEC[1] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_1.MXPA1 ROWEN1A _ROWCKA.NDEC[1] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_2.MXNA1 ROWEN2A _ROWCKA.NDEC[2] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_2.MXPA1 ROWEN2A _ROWCKA.NDEC[2] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_3.MXNA1 ROWEN3A _ROWCKA.NDEC[3] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_3.MXPA1 ROWEN3A _ROWCKA.NDEC[3] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I0_0.MXNA1 _ROWCKB.NDEC[0] NLAB[0] _ROWCKB.I0_0.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_0.MXNA2 _ROWCKB.I0_0.N1 NLAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_0.MXPA1 _ROWCKB.NDEC[0] NLAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_0.MXPA2 _ROWCKB.NDEC[0] NLAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_1.MXNA1 _ROWCKB.NDEC[1] ILAB[0] _ROWCKB.I0_1.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_1.MXNA2 _ROWCKB.I0_1.N1 NLAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_1.MXPA1 _ROWCKB.NDEC[1] ILAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_1.MXPA2 _ROWCKB.NDEC[1] NLAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_2.MXNA1 _ROWCKB.NDEC[2] NLAB[0] _ROWCKB.I0_2.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_2.MXNA2 _ROWCKB.I0_2.N1 ILAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_2.MXPA1 _ROWCKB.NDEC[2] NLAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_2.MXPA2 _ROWCKB.NDEC[2] ILAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_3.MXNA1 _ROWCKB.NDEC[3] ILAB[0] _ROWCKB.I0_3.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_3.MXNA2 _ROWCKB.I0_3.N1 ILAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_3.MXPA1 _ROWCKB.NDEC[3] ILAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_3.MXPA2 _ROWCKB.NDEC[3] ILAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I1_0.MXNA1 ROWEN0B _ROWCKB.NDEC[0] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_0.MXPA1 ROWEN0B _ROWCKB.NDEC[0] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_1.MXNA1 ROWEN1B _ROWCKB.NDEC[1] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_1.MXPA1 ROWEN1B _ROWCKB.NDEC[1] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_2.MXNA1 ROWEN2B _ROWCKB.NDEC[2] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_2.MXPA1 ROWEN2B _ROWCKB.NDEC[2] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_3.MXNA1 ROWEN3B _ROWCKB.NDEC[3] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_3.MXPA1 ROWEN3B _ROWCKB.NDEC[3] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowdrva_0_2_0.I2.MXNA1 _ROWDRVA_0_2_0.NROWCLK GTPA0 _ROWDRVA_0_2_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_0_2_0.I2.MXNA2 _ROWDRVA_0_2_0.I2.N1 ROWEN0A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_0_2_0.I2.MXPA1 _ROWDRVA_0_2_0.NROWCLK GTPA0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_0_2_0.I2.MXPA2 _ROWDRVA_0_2_0.NROWCLK ROWEN0A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_0_2_0.IV_RdWrClk.MXNA1 ROWCLK0A _ROWDRVA_0_2_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_0_2_0.IV_RdWrClk.MXPA1 ROWCLK0A _ROWDRVA_0_2_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_0_2_0.MXN0 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_0_2_0.MXP2 N0A ROWCLK0A VDDC_FDECA0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_0_2_1.I2.MXNA1 _ROWDRVA_0_2_1.NROWCLK GTPA0 _ROWDRVA_0_2_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_0_2_1.I2.MXNA2 _ROWDRVA_0_2_1.I2.N1 ROWEN2A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_0_2_1.I2.MXPA1 _ROWDRVA_0_2_1.NROWCLK GTPA0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_0_2_1.I2.MXPA2 _ROWDRVA_0_2_1.NROWCLK ROWEN2A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_0_2_1.IV_RdWrClk.MXNA1 ROWCLK2A _ROWDRVA_0_2_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_0_2_1.IV_RdWrClk.MXPA1 ROWCLK2A _ROWDRVA_0_2_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_0_2_1.MXN0 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_0_2_1.MXP2 N2A ROWCLK2A VDDC_FDECA0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_1_3_0.I2.MXNA1 _ROWDRVA_1_3_0.NROWCLK GTPA1 _ROWDRVA_1_3_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_1_3_0.I2.MXNA2 _ROWDRVA_1_3_0.I2.N1 ROWEN1A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_1_3_0.I2.MXPA1 _ROWDRVA_1_3_0.NROWCLK GTPA1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_1_3_0.I2.MXPA2 _ROWDRVA_1_3_0.NROWCLK ROWEN1A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_1_3_0.IV_RdWrClk.MXNA1 ROWCLK1A _ROWDRVA_1_3_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_1_3_0.IV_RdWrClk.MXPA1 ROWCLK1A _ROWDRVA_1_3_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_1_3_0.MXN0 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_1_3_0.MXP2 N1A ROWCLK1A VDDC_FDECA1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_1_3_1.I2.MXNA1 _ROWDRVA_1_3_1.NROWCLK GTPA1 _ROWDRVA_1_3_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_1_3_1.I2.MXNA2 _ROWDRVA_1_3_1.I2.N1 ROWEN3A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_1_3_1.I2.MXPA1 _ROWDRVA_1_3_1.NROWCLK GTPA1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_1_3_1.I2.MXPA2 _ROWDRVA_1_3_1.NROWCLK ROWEN3A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_1_3_1.IV_RdWrClk.MXNA1 ROWCLK3A _ROWDRVA_1_3_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_1_3_1.IV_RdWrClk.MXPA1 ROWCLK3A _ROWDRVA_1_3_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_1_3_1.MXN0 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_1_3_1.MXP2 N3A ROWCLK3A VDDC_FDECA1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_0_2_0.I2.MXNA1 _ROWDRVB_0_2_0.NROWCLK GTPB0 _ROWDRVB_0_2_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXNA2 _ROWDRVB_0_2_0.I2.N1 ROWEN0B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXPA1 _ROWDRVB_0_2_0.NROWCLK GTPB0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXPA2 _ROWDRVB_0_2_0.NROWCLK ROWEN0B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_0_2_0.IV_RdWrClk.MXNA1 ROWCLK0B _ROWDRVB_0_2_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_0_2_0.IV_RdWrClk.MXPA1 ROWCLK0B _ROWDRVB_0_2_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_0_2_0.MXN0 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_0_2_0.MXP2 N0B ROWCLK0B VDDC_FDECB0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_0_2_1.I2.MXNA1 _ROWDRVB_0_2_1.NROWCLK GTPB0 _ROWDRVB_0_2_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXNA2 _ROWDRVB_0_2_1.I2.N1 ROWEN2B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXPA1 _ROWDRVB_0_2_1.NROWCLK GTPB0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXPA2 _ROWDRVB_0_2_1.NROWCLK ROWEN2B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_0_2_1.IV_RdWrClk.MXNA1 ROWCLK2B _ROWDRVB_0_2_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_0_2_1.IV_RdWrClk.MXPA1 ROWCLK2B _ROWDRVB_0_2_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_0_2_1.MXN0 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_0_2_1.MXP2 N2B ROWCLK2B VDDC_FDECB0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_1_3_0.I2.MXNA1 _ROWDRVB_1_3_0.NROWCLK GTPB1 _ROWDRVB_1_3_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXNA2 _ROWDRVB_1_3_0.I2.N1 ROWEN1B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXPA1 _ROWDRVB_1_3_0.NROWCLK GTPB1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXPA2 _ROWDRVB_1_3_0.NROWCLK ROWEN1B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_1_3_0.IV_RdWrClk.MXNA1 ROWCLK1B _ROWDRVB_1_3_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_1_3_0.IV_RdWrClk.MXPA1 ROWCLK1B _ROWDRVB_1_3_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_1_3_0.MXN0 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_1_3_0.MXP2 N1B ROWCLK1B VDDC_FDECB1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_1_3_1.I2.MXNA1 _ROWDRVB_1_3_1.NROWCLK GTPB1 _ROWDRVB_1_3_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXNA2 _ROWDRVB_1_3_1.I2.N1 ROWEN3B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXPA1 _ROWDRVB_1_3_1.NROWCLK GTPB1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXPA2 _ROWDRVB_1_3_1.NROWCLK ROWEN3B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_1_3_1.IV_RdWrClk.MXNA1 ROWCLK3B _ROWDRVB_1_3_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_1_3_1.IV_RdWrClk.MXPA1 ROWCLK3B _ROWDRVB_1_3_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_1_3_1.MXN0 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_1_3_1.MXP2 N3B ROWCLK3B VDDC_FDECB1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_wd_base_bot.I8.MX_npd _WD_BASE_BOT.ROWSELA RETA VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_bot.I8._nr.MXNA1 _WD_BASE_BOT.ROWSELA NXAP0_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8._nr.MXNA2 _WD_BASE_BOT.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8._nr.MXPA1 _WD_BASE_BOT.ROWSELA NXAP0_0
+  _WD_BASE_BOT.I8._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I8._nr.MXPA2 _WD_BASE_BOT.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I9.MX_npd _WD_BASE_BOT.ROWSELB RETB VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_bot.I9._nr.MXNA1 _WD_BASE_BOT.ROWSELB NXBP0_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9._nr.MXNA2 _WD_BASE_BOT.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9._nr.MXPA1 _WD_BASE_BOT.ROWSELB NXBP0_0
+  _WD_BASE_BOT.I9._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I9._nr.MXPA2 _WD_BASE_BOT.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwla0.MXN11 WLA0 _WD_BASE_BOT._DRVWLA0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwla0.MXN8 _WD_BASE_BOT._DRVWLA0.NWL _WD_BASE_BOT.ROWSELA
+  N0A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwla0.MXP12 _WD_BASE_BOT._DRVWLA0.NWL ROWCLK0A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwla0.MXP13 _WD_BASE_BOT._DRVWLA0.NWL _WD_BASE_BOT.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwla0.MXP7 WLA0 _WD_BASE_BOT._DRVWLA0.NWL VDDC_WLA0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwla1.MXN11 WLA1 _WD_BASE_BOT._DRVWLA1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwla1.MXN8 _WD_BASE_BOT._DRVWLA1.NWL _WD_BASE_BOT.ROWSELA
+  N1A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwla1.MXP12 _WD_BASE_BOT._DRVWLA1.NWL ROWCLK1A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwla1.MXP13 _WD_BASE_BOT._DRVWLA1.NWL _WD_BASE_BOT.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwla1.MXP7 WLA1 _WD_BASE_BOT._DRVWLA1.NWL VDDC_WLA1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwlb0.MXN11 WLB0 _WD_BASE_BOT._DRVWLB0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwlb0.MXN8 _WD_BASE_BOT._DRVWLB0.NWL _WD_BASE_BOT.ROWSELB
+  N0B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP12 _WD_BASE_BOT._DRVWLB0.NWL ROWCLK0B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP13 _WD_BASE_BOT._DRVWLB0.NWL _WD_BASE_BOT.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP7 WLB0 _WD_BASE_BOT._DRVWLB0.NWL VDDC_WLB0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwlb1.MXN11 WLB1 _WD_BASE_BOT._DRVWLB1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwlb1.MXN8 _WD_BASE_BOT._DRVWLB1.NWL _WD_BASE_BOT.ROWSELB
+  N1B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP12 _WD_BASE_BOT._DRVWLB1.NWL ROWCLK1B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP13 _WD_BASE_BOT._DRVWLB1.NWL _WD_BASE_BOT.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP7 WLB1 _WD_BASE_BOT._DRVWLB1.NWL VDDC_WLB1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top.I8.MX_npd _WD_BASE_TOP.ROWSELA RETA VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_top.I8._nr.MXNA1 _WD_BASE_TOP.ROWSELA NXAP0_7 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8._nr.MXNA2 _WD_BASE_TOP.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8._nr.MXPA1 _WD_BASE_TOP.ROWSELA NXAP0_7
+  _WD_BASE_TOP.I8._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I8._nr.MXPA2 _WD_BASE_TOP.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I9.MX_npd _WD_BASE_TOP.ROWSELB RETB VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_top.I9._nr.MXNA1 _WD_BASE_TOP.ROWSELB NXBP0_7 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9._nr.MXNA2 _WD_BASE_TOP.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9._nr.MXPA1 _WD_BASE_TOP.ROWSELB NXBP0_7
+  _WD_BASE_TOP.I9._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I9._nr.MXPA2 _WD_BASE_TOP.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwla0.MXN11 WLA30 _WD_BASE_TOP._DRVWLA0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwla0.MXN8 _WD_BASE_TOP._DRVWLA0.NWL _WD_BASE_TOP.ROWSELA
+  N2A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwla0.MXP12 _WD_BASE_TOP._DRVWLA0.NWL ROWCLK2A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwla0.MXP13 _WD_BASE_TOP._DRVWLA0.NWL _WD_BASE_TOP.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwla0.MXP7 WLA30 _WD_BASE_TOP._DRVWLA0.NWL VDDC_WLA0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwla1.MXN11 WLA31 _WD_BASE_TOP._DRVWLA1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwla1.MXN8 _WD_BASE_TOP._DRVWLA1.NWL _WD_BASE_TOP.ROWSELA
+  N3A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwla1.MXP12 _WD_BASE_TOP._DRVWLA1.NWL ROWCLK3A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwla1.MXP13 _WD_BASE_TOP._DRVWLA1.NWL _WD_BASE_TOP.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwla1.MXP7 WLA31 _WD_BASE_TOP._DRVWLA1.NWL VDDC_WLA1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwlb0.MXN11 WLB30 _WD_BASE_TOP._DRVWLB0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwlb0.MXN8 _WD_BASE_TOP._DRVWLB0.NWL _WD_BASE_TOP.ROWSELB
+  N2B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwlb0.MXP12 _WD_BASE_TOP._DRVWLB0.NWL ROWCLK2B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwlb0.MXP13 _WD_BASE_TOP._DRVWLB0.NWL _WD_BASE_TOP.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwlb0.MXP7 WLB30 _WD_BASE_TOP._DRVWLB0.NWL VDDC_WLB0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwlb1.MXN11 WLB31 _WD_BASE_TOP._DRVWLB1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwlb1.MXN8 _WD_BASE_TOP._DRVWLB1.NWL _WD_BASE_TOP.ROWSELB
+  N3B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwlb1.MXP12 _WD_BASE_TOP._DRVWLB1.NWL ROWCLK3B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwlb1.MXP13 _WD_BASE_TOP._DRVWLB1.NWL _WD_BASE_TOP.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwlb1.MXP7 WLB31 _WD_BASE_TOP._DRVWLB1.NWL VDDC_WLB1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_dp299_dbla_0.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_0.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_1.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_1.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_10.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_10.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_11.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_11.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_12.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_12.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_13.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_13.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_14.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_14.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_15.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_15.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_2.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_2.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_3.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_3.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_4.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_4.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_5.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_5.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_6.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_6.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_7.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_7.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_8.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_8.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_9.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_9.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_0.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_0.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_1.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_1.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_10.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_10.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_11.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_11.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_12.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_12.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_13.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_13.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_14.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_14.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_15.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_15.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_2.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_2.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_3.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_3.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_4.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_4.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_5.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_5.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_6.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_6.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_7.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_7.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_8.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_8.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_9.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_9.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_xp0a._dec.I1_0.MXNA1 _XP0A._DEC.NDEC[0] NRAA[0] _XP0A._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_0.MXNA2 _XP0A._DEC.I1_0.N2 NRAA[1] _XP0A._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_0.MXNA3 _XP0A._DEC.I1_0.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_0.MXPA1 _XP0A._DEC.NDEC[0] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_0.MXPA2 _XP0A._DEC.NDEC[0] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_0.MXPA3 _XP0A._DEC.NDEC[0] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXNA1 _XP0A._DEC.NDEC[1] IRAA[0] _XP0A._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_1.MXNA2 _XP0A._DEC.I1_1.N2 NRAA[1] _XP0A._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_1.MXNA3 _XP0A._DEC.I1_1.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_1.MXPA1 _XP0A._DEC.NDEC[1] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXPA2 _XP0A._DEC.NDEC[1] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXPA3 _XP0A._DEC.NDEC[1] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXNA1 _XP0A._DEC.NDEC[2] NRAA[0] _XP0A._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_2.MXNA2 _XP0A._DEC.I1_2.N2 IRAA[1] _XP0A._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_2.MXNA3 _XP0A._DEC.I1_2.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_2.MXPA1 _XP0A._DEC.NDEC[2] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXPA2 _XP0A._DEC.NDEC[2] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXPA3 _XP0A._DEC.NDEC[2] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXNA1 _XP0A._DEC.NDEC[3] IRAA[0] _XP0A._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_3.MXNA2 _XP0A._DEC.I1_3.N2 IRAA[1] _XP0A._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_3.MXNA3 _XP0A._DEC.I1_3.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_3.MXPA1 _XP0A._DEC.NDEC[3] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXPA2 _XP0A._DEC.NDEC[3] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXPA3 _XP0A._DEC.NDEC[3] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXNA1 _XP0A._DEC.NDEC[4] NRAA[0] _XP0A._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_4.MXNA2 _XP0A._DEC.I1_4.N2 NRAA[1] _XP0A._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_4.MXNA3 _XP0A._DEC.I1_4.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_4.MXPA1 _XP0A._DEC.NDEC[4] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXPA2 _XP0A._DEC.NDEC[4] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXPA3 _XP0A._DEC.NDEC[4] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXNA1 _XP0A._DEC.NDEC[5] IRAA[0] _XP0A._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_5.MXNA2 _XP0A._DEC.I1_5.N2 NRAA[1] _XP0A._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_5.MXNA3 _XP0A._DEC.I1_5.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_5.MXPA1 _XP0A._DEC.NDEC[5] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXPA2 _XP0A._DEC.NDEC[5] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXPA3 _XP0A._DEC.NDEC[5] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXNA1 _XP0A._DEC.NDEC[6] NRAA[0] _XP0A._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_6.MXNA2 _XP0A._DEC.I1_6.N2 IRAA[1] _XP0A._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_6.MXNA3 _XP0A._DEC.I1_6.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_6.MXPA1 _XP0A._DEC.NDEC[6] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXPA2 _XP0A._DEC.NDEC[6] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXPA3 _XP0A._DEC.NDEC[6] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXNA1 _XP0A._DEC.NDEC[7] IRAA[0] _XP0A._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_7.MXNA2 _XP0A._DEC.I1_7.N2 IRAA[1] _XP0A._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_7.MXNA3 _XP0A._DEC.I1_7.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_7.MXPA1 _XP0A._DEC.NDEC[7] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXPA2 _XP0A._DEC.NDEC[7] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXPA3 _XP0A._DEC.NDEC[7] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I3_0.MXNA1 _XP0A.XP[0] _XP0A._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_0.MXPA1 _XP0A.XP[0] _XP0A._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_1.MXNA1 _XP0A.XP[1] _XP0A._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_1.MXPA1 _XP0A.XP[1] _XP0A._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_2.MXNA1 _XP0A.XP[2] _XP0A._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_2.MXPA1 _XP0A.XP[2] _XP0A._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_3.MXNA1 _XP0A.XP[3] _XP0A._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_3.MXPA1 _XP0A.XP[3] _XP0A._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_4.MXNA1 _XP0A.XP[4] _XP0A._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_4.MXPA1 _XP0A.XP[4] _XP0A._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_5.MXNA1 _XP0A.XP[5] _XP0A._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_5.MXPA1 _XP0A.XP[5] _XP0A._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_6.MXNA1 _XP0A.XP[6] _XP0A._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_6.MXPA1 _XP0A.XP[6] _XP0A._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_7.MXNA1 _XP0A.XP[7] _XP0A._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_7.MXPA1 _XP0A.XP[7] _XP0A._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._iv_nxp_0.MXNA1 NXAP0_0 _XP0A.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_0.MXPA1 NXAP0_0 _XP0A.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_1.MXNA1 NXAP0_1 _XP0A.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_1.MXPA1 NXAP0_1 _XP0A.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_2.MXNA1 NXAP0_2 _XP0A.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_2.MXPA1 NXAP0_2 _XP0A.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_3.MXNA1 NXAP0_3 _XP0A.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_3.MXPA1 NXAP0_3 _XP0A.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_4.MXNA1 NXAP0_4 _XP0A.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_4.MXPA1 NXAP0_4 _XP0A.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_5.MXNA1 NXAP0_5 _XP0A.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_5.MXPA1 NXAP0_5 _XP0A.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_6.MXNA1 NXAP0_6 _XP0A.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_6.MXPA1 NXAP0_6 _XP0A.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_7.MXNA1 NXAP0_7 _XP0A.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_7.MXPA1 NXAP0_7 _XP0A.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._dec.I1_0.MXNA1 _XP0B._DEC.NDEC[0] NRAB[0] _XP0B._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_0.MXNA2 _XP0B._DEC.I1_0.N2 NRAB[1] _XP0B._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_0.MXNA3 _XP0B._DEC.I1_0.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_0.MXPA1 _XP0B._DEC.NDEC[0] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_0.MXPA2 _XP0B._DEC.NDEC[0] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_0.MXPA3 _XP0B._DEC.NDEC[0] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXNA1 _XP0B._DEC.NDEC[1] IRAB[0] _XP0B._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_1.MXNA2 _XP0B._DEC.I1_1.N2 NRAB[1] _XP0B._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_1.MXNA3 _XP0B._DEC.I1_1.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_1.MXPA1 _XP0B._DEC.NDEC[1] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXPA2 _XP0B._DEC.NDEC[1] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXPA3 _XP0B._DEC.NDEC[1] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXNA1 _XP0B._DEC.NDEC[2] NRAB[0] _XP0B._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_2.MXNA2 _XP0B._DEC.I1_2.N2 IRAB[1] _XP0B._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_2.MXNA3 _XP0B._DEC.I1_2.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_2.MXPA1 _XP0B._DEC.NDEC[2] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXPA2 _XP0B._DEC.NDEC[2] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXPA3 _XP0B._DEC.NDEC[2] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXNA1 _XP0B._DEC.NDEC[3] IRAB[0] _XP0B._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_3.MXNA2 _XP0B._DEC.I1_3.N2 IRAB[1] _XP0B._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_3.MXNA3 _XP0B._DEC.I1_3.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_3.MXPA1 _XP0B._DEC.NDEC[3] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXPA2 _XP0B._DEC.NDEC[3] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXPA3 _XP0B._DEC.NDEC[3] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXNA1 _XP0B._DEC.NDEC[4] NRAB[0] _XP0B._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_4.MXNA2 _XP0B._DEC.I1_4.N2 NRAB[1] _XP0B._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_4.MXNA3 _XP0B._DEC.I1_4.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_4.MXPA1 _XP0B._DEC.NDEC[4] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXPA2 _XP0B._DEC.NDEC[4] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXPA3 _XP0B._DEC.NDEC[4] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXNA1 _XP0B._DEC.NDEC[5] IRAB[0] _XP0B._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_5.MXNA2 _XP0B._DEC.I1_5.N2 NRAB[1] _XP0B._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_5.MXNA3 _XP0B._DEC.I1_5.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_5.MXPA1 _XP0B._DEC.NDEC[5] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXPA2 _XP0B._DEC.NDEC[5] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXPA3 _XP0B._DEC.NDEC[5] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXNA1 _XP0B._DEC.NDEC[6] NRAB[0] _XP0B._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_6.MXNA2 _XP0B._DEC.I1_6.N2 IRAB[1] _XP0B._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_6.MXNA3 _XP0B._DEC.I1_6.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_6.MXPA1 _XP0B._DEC.NDEC[6] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXPA2 _XP0B._DEC.NDEC[6] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXPA3 _XP0B._DEC.NDEC[6] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXNA1 _XP0B._DEC.NDEC[7] IRAB[0] _XP0B._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_7.MXNA2 _XP0B._DEC.I1_7.N2 IRAB[1] _XP0B._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_7.MXNA3 _XP0B._DEC.I1_7.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_7.MXPA1 _XP0B._DEC.NDEC[7] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXPA2 _XP0B._DEC.NDEC[7] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXPA3 _XP0B._DEC.NDEC[7] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I3_0.MXNA1 _XP0B.XP[0] _XP0B._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_0.MXPA1 _XP0B.XP[0] _XP0B._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_1.MXNA1 _XP0B.XP[1] _XP0B._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_1.MXPA1 _XP0B.XP[1] _XP0B._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_2.MXNA1 _XP0B.XP[2] _XP0B._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_2.MXPA1 _XP0B.XP[2] _XP0B._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_3.MXNA1 _XP0B.XP[3] _XP0B._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_3.MXPA1 _XP0B.XP[3] _XP0B._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_4.MXNA1 _XP0B.XP[4] _XP0B._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_4.MXPA1 _XP0B.XP[4] _XP0B._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_5.MXNA1 _XP0B.XP[5] _XP0B._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_5.MXPA1 _XP0B.XP[5] _XP0B._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_6.MXNA1 _XP0B.XP[6] _XP0B._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_6.MXPA1 _XP0B.XP[6] _XP0B._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_7.MXNA1 _XP0B.XP[7] _XP0B._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_7.MXPA1 _XP0B.XP[7] _XP0B._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._iv_nxp_0.MXNA1 NXBP0_0 _XP0B.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_0.MXPA1 NXBP0_0 _XP0B.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_1.MXNA1 NXBP0_1 _XP0B.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_1.MXPA1 NXBP0_1 _XP0B.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_2.MXNA1 NXBP0_2 _XP0B.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_2.MXPA1 NXBP0_2 _XP0B.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_3.MXNA1 NXBP0_3 _XP0B.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_3.MXPA1 NXBP0_3 _XP0B.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_4.MXNA1 NXBP0_4 _XP0B.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_4.MXPA1 NXBP0_4 _XP0B.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_5.MXNA1 NXBP0_5 _XP0B.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_5.MXPA1 NXBP0_5 _XP0B.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_6.MXNA1 NXBP0_6 _XP0B.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_6.MXPA1 NXBP0_6 _XP0B.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_7.MXNA1 NXBP0_7 _XP0B.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_7.MXPA1 NXBP0_7 _XP0B.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._dec.I1_0.MXNA1 _XP1A._DEC.NDEC[0] NRAA[3] _XP1A._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_0.MXNA2 _XP1A._DEC.I1_0.N2 NRAA[4] _XP1A._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_0.MXNA3 _XP1A._DEC.I1_0.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_0.MXPA1 _XP1A._DEC.NDEC[0] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_0.MXPA2 _XP1A._DEC.NDEC[0] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_0.MXPA3 _XP1A._DEC.NDEC[0] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXNA1 _XP1A._DEC.NDEC[1] IRAA[3] _XP1A._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_1.MXNA2 _XP1A._DEC.I1_1.N2 NRAA[4] _XP1A._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_1.MXNA3 _XP1A._DEC.I1_1.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_1.MXPA1 _XP1A._DEC.NDEC[1] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXPA2 _XP1A._DEC.NDEC[1] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXPA3 _XP1A._DEC.NDEC[1] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXNA1 _XP1A._DEC.NDEC[2] NRAA[3] _XP1A._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_2.MXNA2 _XP1A._DEC.I1_2.N2 IRAA[4] _XP1A._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_2.MXNA3 _XP1A._DEC.I1_2.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_2.MXPA1 _XP1A._DEC.NDEC[2] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXPA2 _XP1A._DEC.NDEC[2] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXPA3 _XP1A._DEC.NDEC[2] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXNA1 _XP1A._DEC.NDEC[3] IRAA[3] _XP1A._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_3.MXNA2 _XP1A._DEC.I1_3.N2 IRAA[4] _XP1A._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_3.MXNA3 _XP1A._DEC.I1_3.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_3.MXPA1 _XP1A._DEC.NDEC[3] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXPA2 _XP1A._DEC.NDEC[3] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXPA3 _XP1A._DEC.NDEC[3] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXNA1 _XP1A._DEC.NDEC[4] NRAA[3] _XP1A._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_4.MXNA2 _XP1A._DEC.I1_4.N2 NRAA[4] _XP1A._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_4.MXNA3 _XP1A._DEC.I1_4.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_4.MXPA1 _XP1A._DEC.NDEC[4] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXPA2 _XP1A._DEC.NDEC[4] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXPA3 _XP1A._DEC.NDEC[4] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXNA1 _XP1A._DEC.NDEC[5] IRAA[3] _XP1A._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_5.MXNA2 _XP1A._DEC.I1_5.N2 NRAA[4] _XP1A._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_5.MXNA3 _XP1A._DEC.I1_5.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_5.MXPA1 _XP1A._DEC.NDEC[5] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXPA2 _XP1A._DEC.NDEC[5] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXPA3 _XP1A._DEC.NDEC[5] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXNA1 _XP1A._DEC.NDEC[6] NRAA[3] _XP1A._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_6.MXNA2 _XP1A._DEC.I1_6.N2 IRAA[4] _XP1A._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_6.MXNA3 _XP1A._DEC.I1_6.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_6.MXPA1 _XP1A._DEC.NDEC[6] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXPA2 _XP1A._DEC.NDEC[6] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXPA3 _XP1A._DEC.NDEC[6] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXNA1 _XP1A._DEC.NDEC[7] IRAA[3] _XP1A._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_7.MXNA2 _XP1A._DEC.I1_7.N2 IRAA[4] _XP1A._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_7.MXNA3 _XP1A._DEC.I1_7.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_7.MXPA1 _XP1A._DEC.NDEC[7] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXPA2 _XP1A._DEC.NDEC[7] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXPA3 _XP1A._DEC.NDEC[7] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I3_0.MXNA1 _XP1A.XP[0] _XP1A._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_0.MXPA1 _XP1A.XP[0] _XP1A._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_1.MXNA1 _XP1A.XP[1] _XP1A._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_1.MXPA1 _XP1A.XP[1] _XP1A._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_2.MXNA1 _XP1A.XP[2] _XP1A._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_2.MXPA1 _XP1A.XP[2] _XP1A._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_3.MXNA1 _XP1A.XP[3] _XP1A._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_3.MXPA1 _XP1A.XP[3] _XP1A._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_4.MXNA1 _XP1A.XP[4] _XP1A._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_4.MXPA1 _XP1A.XP[4] _XP1A._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_5.MXNA1 _XP1A.XP[5] _XP1A._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_5.MXPA1 _XP1A.XP[5] _XP1A._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_6.MXNA1 _XP1A.XP[6] _XP1A._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_6.MXPA1 _XP1A.XP[6] _XP1A._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_7.MXNA1 _XP1A.XP[7] _XP1A._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_7.MXPA1 _XP1A.XP[7] _XP1A._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._iv_nxp_0.MXNA1 NXAP1_0 _XP1A.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_0.MXPA1 NXAP1_0 _XP1A.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_1.MXNA1 NXAP1_1 _XP1A.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_1.MXPA1 NXAP1_1 _XP1A.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_2.MXNA1 NXAP1_2 _XP1A.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_2.MXPA1 NXAP1_2 _XP1A.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_3.MXNA1 NXAP1_3 _XP1A.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_3.MXPA1 NXAP1_3 _XP1A.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_4.MXNA1 NXAP1_4 _XP1A.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_4.MXPA1 NXAP1_4 _XP1A.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_5.MXNA1 NXAP1_5 _XP1A.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_5.MXPA1 NXAP1_5 _XP1A.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_6.MXNA1 NXAP1_6 _XP1A.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_6.MXPA1 NXAP1_6 _XP1A.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_7.MXNA1 NXAP1_7 _XP1A.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_7.MXPA1 NXAP1_7 _XP1A.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._dec.I1_0.MXNA1 _XP1B._DEC.NDEC[0] NRAB[3] _XP1B._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_0.MXNA2 _XP1B._DEC.I1_0.N2 NRAB[4] _XP1B._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_0.MXNA3 _XP1B._DEC.I1_0.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_0.MXPA1 _XP1B._DEC.NDEC[0] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_0.MXPA2 _XP1B._DEC.NDEC[0] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_0.MXPA3 _XP1B._DEC.NDEC[0] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXNA1 _XP1B._DEC.NDEC[1] IRAB[3] _XP1B._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_1.MXNA2 _XP1B._DEC.I1_1.N2 NRAB[4] _XP1B._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_1.MXNA3 _XP1B._DEC.I1_1.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_1.MXPA1 _XP1B._DEC.NDEC[1] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXPA2 _XP1B._DEC.NDEC[1] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXPA3 _XP1B._DEC.NDEC[1] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXNA1 _XP1B._DEC.NDEC[2] NRAB[3] _XP1B._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_2.MXNA2 _XP1B._DEC.I1_2.N2 IRAB[4] _XP1B._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_2.MXNA3 _XP1B._DEC.I1_2.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_2.MXPA1 _XP1B._DEC.NDEC[2] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXPA2 _XP1B._DEC.NDEC[2] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXPA3 _XP1B._DEC.NDEC[2] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXNA1 _XP1B._DEC.NDEC[3] IRAB[3] _XP1B._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_3.MXNA2 _XP1B._DEC.I1_3.N2 IRAB[4] _XP1B._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_3.MXNA3 _XP1B._DEC.I1_3.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_3.MXPA1 _XP1B._DEC.NDEC[3] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXPA2 _XP1B._DEC.NDEC[3] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXPA3 _XP1B._DEC.NDEC[3] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXNA1 _XP1B._DEC.NDEC[4] NRAB[3] _XP1B._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_4.MXNA2 _XP1B._DEC.I1_4.N2 NRAB[4] _XP1B._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_4.MXNA3 _XP1B._DEC.I1_4.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_4.MXPA1 _XP1B._DEC.NDEC[4] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXPA2 _XP1B._DEC.NDEC[4] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXPA3 _XP1B._DEC.NDEC[4] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXNA1 _XP1B._DEC.NDEC[5] IRAB[3] _XP1B._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_5.MXNA2 _XP1B._DEC.I1_5.N2 NRAB[4] _XP1B._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_5.MXNA3 _XP1B._DEC.I1_5.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_5.MXPA1 _XP1B._DEC.NDEC[5] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXPA2 _XP1B._DEC.NDEC[5] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXPA3 _XP1B._DEC.NDEC[5] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXNA1 _XP1B._DEC.NDEC[6] NRAB[3] _XP1B._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_6.MXNA2 _XP1B._DEC.I1_6.N2 IRAB[4] _XP1B._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_6.MXNA3 _XP1B._DEC.I1_6.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_6.MXPA1 _XP1B._DEC.NDEC[6] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXPA2 _XP1B._DEC.NDEC[6] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXPA3 _XP1B._DEC.NDEC[6] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXNA1 _XP1B._DEC.NDEC[7] IRAB[3] _XP1B._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_7.MXNA2 _XP1B._DEC.I1_7.N2 IRAB[4] _XP1B._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_7.MXNA3 _XP1B._DEC.I1_7.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_7.MXPA1 _XP1B._DEC.NDEC[7] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXPA2 _XP1B._DEC.NDEC[7] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXPA3 _XP1B._DEC.NDEC[7] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I3_0.MXNA1 _XP1B.XP[0] _XP1B._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_0.MXPA1 _XP1B.XP[0] _XP1B._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_1.MXNA1 _XP1B.XP[1] _XP1B._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_1.MXPA1 _XP1B.XP[1] _XP1B._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_2.MXNA1 _XP1B.XP[2] _XP1B._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_2.MXPA1 _XP1B.XP[2] _XP1B._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_3.MXNA1 _XP1B.XP[3] _XP1B._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_3.MXPA1 _XP1B.XP[3] _XP1B._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_4.MXNA1 _XP1B.XP[4] _XP1B._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_4.MXPA1 _XP1B.XP[4] _XP1B._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_5.MXNA1 _XP1B.XP[5] _XP1B._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_5.MXPA1 _XP1B.XP[5] _XP1B._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_6.MXNA1 _XP1B.XP[6] _XP1B._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_6.MXPA1 _XP1B.XP[6] _XP1B._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_7.MXNA1 _XP1B.XP[7] _XP1B._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_7.MXPA1 _XP1B.XP[7] _XP1B._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._iv_nxp_0.MXNA1 NXBP1_0 _XP1B.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_0.MXPA1 NXBP1_0 _XP1B.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_1.MXNA1 NXBP1_1 _XP1B.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_1.MXPA1 NXBP1_1 _XP1B.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_2.MXNA1 NXBP1_2 _XP1B.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_2.MXPA1 NXBP1_2 _XP1B.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_3.MXNA1 NXBP1_3 _XP1B.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_3.MXPA1 NXBP1_3 _XP1B.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_4.MXNA1 NXBP1_4 _XP1B.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_4.MXPA1 NXBP1_4 _XP1B.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_5.MXNA1 NXBP1_5 _XP1B.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_5.MXPA1 NXBP1_5 _XP1B.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_6.MXNA1 NXBP1_6 _XP1B.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_6.MXPA1 NXBP1_6 _XP1B.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_7.MXNA1 NXBP1_7 _XP1B.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_7.MXPA1 NXBP1_7 _XP1B.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
.ENDS RAMTP1024X16WD32X2
****
.SUBCKT RAMTP1024X16WD2X2STRAP DBLA DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B
+  N2A N2B N3A N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4
+  NXAP0_5 NXAP0_6 NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5
+  NXAP1_6 NXAP1_7 NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6
+  NXBP0_7 NXBP1_0 NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7
+  RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0 VDDC_FDECA2 VDDC_FDECA3
+  VDDC_FDECB0 VDDC_FDECB2 VDDC_FDECB3 VDDC_WLA VDDC_WLB VDDPE VDDP_WDA
+  VDDP_WDB VNWC VNWP VPW VSS VSSE
** RAMTP1024X16WD2X2STRAP: 8 flat devices **
X_MI1_1.MXP0 N3B ROWCLK3B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI1_1.MXP2 N1B ROWCLK1B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP0 N2B ROWCLK2B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP2 N0B ROWCLK0B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_0.MXP0 N2A ROWCLK2A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_0.MXP2 N0A ROWCLK0A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP0 N3A ROWCLK3A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP2 N1A ROWCLK1A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
.ENDS RAMTP1024X16WD2X2STRAP
****
.SUBCKT RAMTP1024X16WD2X2TOP DBLA DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A
+  N2B N3A N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5
+  NXAP0_6 NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6
+  NXAP1_7 NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7
+  NXBP1_0 NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RETA RETB
+  ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B
+  VDDC VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECA2
+  VDDC_FDECA3 VDDC_FDECB0 VDDC_FDECB1 VDDC_FDECB2 VDDC_FDECB3 VDDC_WLA0
+  VDDC_WLA1 VDDC_WLB0 VDDC_WLB1 VDDPE VDDP_WDA VDDP_WDB VNWC VNWP VPW VSS
+  VSSE
** RAMTP1024X16WD2X2TOP: 12 flat devices **
X_MI100.MXP2 VDDC_FDECB0 RETB VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_MI1_1.MXP0 N3B ROWCLK3B VDDC_FDECB1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI1_1.MXP2 N1B ROWCLK1B VDDC_FDECB1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP0 N2B ROWCLK2B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP2 N0B ROWCLK0B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI99.MXP2 VDDC_FDECB1 RETB VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_MRowDum_0.MXP0 N2A ROWCLK2A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_0.MXP2 N0A ROWCLK0A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP0 N3A ROWCLK3A VDDC_FDECA1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP2 N1A ROWCLK1A VDDC_FDECA1 VNWC P11LL_CKT W=1.67U L=0.04U
X_M_fdechdra0.MXP2 VDDC_FDECA0 RETA VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_M_fdechdra1.MXP2 VDDC_FDECA1 RETA VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
.ENDS RAMTP1024X16WD2X2TOP
****
.SUBCKT RAMTP1024X16WD_STACK DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1]
+  LOG0_DWLA LOG0_DWLB LOG1A LOG1B NACTC NRETNVT RAA[0] RAA[1] RAA[2] RAA[3]
+  RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC
+  VDDC_FDECA0 VDDC_FDECB0 VDDPE VPW WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63
+  WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72
+  WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81
+  WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90
+  WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99
+  WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107
+  WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA2 WLA3 WLA4 WLA5 WLA6 WLA7
+  WLA8 WLA9 WLA10 WLA11 WLA12 WLA13 WLA14 WLA15 WLA16 WLA17 WLA18 WLA19 WLA20
+  WLA21 WLA22 WLA23 WLA24 WLA25 WLA26 WLA27 WLA28 WLA29 WLA30 WLA31 WLB0_0
+  WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10
+  WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19
+  WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28
+  WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37
+  WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46
+  WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55
+  WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64
+  WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73
+  WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82
+  WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91
+  WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100
+  WLB0_101 WLB0_102 WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108
+  WLB0_109 WLB0_110 WLB0_111 WLB0_112 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4
+  WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14
+  WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23
+  WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32
+  WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41
+  WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50
+  WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59
+  WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68
+  WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77
+  WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86
+  WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95
+  WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB2 WLB3 WLB4 WLB5 WLB6 WLB7 WLB8 WLB9 WLB10 WLB11 WLB12 WLB13
+  WLB14 WLB15 WLB16 WLB17 WLB18 WLB19 WLB20 WLB21 WLB22 WLB23 WLB24 WLB25
+  WLB26 WLB27 WLB28 WLB29 WLB30 WLB31
** RAMTP1024X16WD_STACK: 6047 flat devices **
XBOTWDBLOCK DBLA DBLA_OUT DBLA_OUT DBLA DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1]
+  LOG0_DWLA LOG0_DWLB LOG1A LOG1B N0A N0B N1A N1B N2A N2B N3A N3B NACTC
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RAA[0] RAA[1] RAA[2] RAA[3]
+  RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB ROWCLK0A
+  ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDC
+  VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0 VDDC_FDECB0 VDDC VDDC VDDC
+  VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW VPW WLA0_0 WLA1_0 WLA2 WLA3
+  WLA4 WLA5 WLA6 WLA7 WLA8 WLA9 WLA10 WLA11 WLA12 WLA13 WLA14 WLA15 WLA16
+  WLA17 WLA18 WLA19 WLA20 WLA21 WLA22 WLA23 WLA24 WLA25 WLA26 WLA27 WLA28
+  WLA29 WLA30 WLA31 WLB0_0 WLB1_0 WLB2 WLB3 WLB4 WLB5 WLB6 WLB7 WLB8 WLB9
+  WLB10 WLB11 WLB12 WLB13 WLB14 WLB15 WLB16 WLB17 WLB18 WLB19 WLB20 WLB21
+  WLB22 WLB23 WLB24 WLB25 WLB26 WLB27 WLB28 WLB29 WLB30 WLB31
+  RAMTP1024X16WD32X2
XI100 DBLA DBLA_DUM0_225 DBLA_DUM1_227 DBLB NXAP0_1 NXAP1_6 NXBP0_1 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_84 WLA1_84 WLB0_84 WLB1_84 RAMTP1024X16WD2X2
XI101 DBLA DBLA_DUM0_229 DBLA_DUM1_231 DBLB NXAP0_2 NXAP1_6 NXBP0_2 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_85 WLA1_85 WLB0_85 WLB1_85 RAMTP1024X16WD2X2
XI102 DBLA DBLA_DUM0_233 DBLA_DUM1_235 DBLB NXAP0_2 NXAP1_6 NXBP0_2 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_86 WLA1_86 WLB0_86 WLB1_86 RAMTP1024X16WD2X2
XI103 DBLA DBLA_DUM0_241 DBLA_DUM1_243 DBLB NXAP0_3 NXAP1_6 NXBP0_3 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_87 WLA1_87 WLB0_87 WLB1_87 RAMTP1024X16WD2X2
XI104 DBLA DBLA_DUM0_249 DBLA_DUM1_251 DBLB NXAP0_3 NXAP1_6 NXBP0_3 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_88 WLA1_88 WLB0_88 WLB1_88 RAMTP1024X16WD2X2
XI105 DBLA DBLA_DUM0_257 DBLA_DUM1_259 DBLB NXAP0_4 NXAP1_6 NXBP0_4 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_89 WLA1_89 WLB0_89 WLB1_89 RAMTP1024X16WD2X2
XI106 DBLA DBLA_DUM0_265 DBLA_DUM1_267 DBLB NXAP0_4 NXAP1_6 NXBP0_4 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_90 WLA1_90 WLB0_90 WLB1_90 RAMTP1024X16WD2X2
XI107 DBLA DBLA_DUM0_273 DBLA_DUM1_275 DBLB NXAP0_5 NXAP1_6 NXBP0_5 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_91 WLA1_91 WLB0_91 WLB1_91 RAMTP1024X16WD2X2
XI108 DBLA DBLA_DUM0_281 DBLA_DUM1_283 DBLB NXAP0_5 NXAP1_6 NXBP0_5 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_92 WLA1_92 WLB0_92 WLB1_92 RAMTP1024X16WD2X2
XI109 DBLA DBLA_DUM0_289 DBLA_DUM1_291 DBLB NXAP0_6 NXAP1_6 NXBP0_6 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_93 WLA1_93 WLB0_93 WLB1_93 RAMTP1024X16WD2X2
XI110 DBLA DBLA_DUM0_477 DBLA_DUM1_479 DBLB NXAP0_6 NXAP1_6 NXBP0_6 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_94 WLA1_94 WLB0_94 WLB1_94 RAMTP1024X16WD2X2
XI111 DBLA DBLA_DUM0_481 DBLA_DUM1_483 DBLB NXAP0_7 NXAP1_6 NXBP0_7 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_95 WLA1_95 WLB0_95 WLB1_95 RAMTP1024X16WD2X2
XI112 DBLA DBLA_DUM0_485 DBLA_DUM1_487 DBLB NXAP0_7 NXAP1_6 NXBP0_7 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_96 WLA1_96 WLB0_96 WLB1_96 RAMTP1024X16WD2X2
XI113 DBLA DBLA_DUM0_489 DBLA_DUM1_491 DBLB NXAP0_0 NXAP1_7 NXBP0_0 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_97 WLA1_97 WLB0_97 WLB1_97 RAMTP1024X16WD2X2
XI114 DBLA DBLA_DUM0_493 DBLA_DUM1_495 DBLB NXAP0_0 NXAP1_7 NXBP0_0 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_98 WLA1_98 WLB0_98 WLB1_98 RAMTP1024X16WD2X2
XI115 DBLA DBLA_DUM0 DBLA_DUM1 DBLB NXAP0_1 NXAP1_7 NXBP0_1 NXBP1_7 LOG0_DWLA
+  LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B NRETNVT
+  NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7 NXAP1_0
+  NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0 NXBP0_1
+  NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1 NXBP1_2
+  NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B
+  RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0 VDDC_FDECB0
+  VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW VPW WLA0_99
+  WLA1_99 WLB0_99 WLB1_99 RAMTP1024X16WD2X2
XI116 DBLA DBLA_DUM0_53 DBLA_DUM1_55 DBLB NXAP0_1 NXAP1_7 NXBP0_1 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_100 WLA1_100 WLB0_100 WLB1_100 RAMTP1024X16WD2X2
XI117 DBLA DBLA_DUM0_57 DBLA_DUM1_59 DBLB NXAP0_2 NXAP1_7 NXBP0_2 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_101 WLA1_101 WLB0_101 WLB1_101 RAMTP1024X16WD2X2
XI118 DBLA DBLA_DUM0_61 DBLA_DUM1_63 DBLB NXAP0_2 NXAP1_7 NXBP0_2 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_102 WLA1_102 WLB0_102 WLB1_102 RAMTP1024X16WD2X2
XI119 DBLA DBLA_DUM0_65 DBLA_DUM1_67 DBLB NXAP0_3 NXAP1_7 NXBP0_3 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_103 WLA1_103 WLB0_103 WLB1_103 RAMTP1024X16WD2X2
XI120 DBLA DBLA_DUM0_237 DBLA_DUM1_239 DBLB NXAP0_3 NXAP1_7 NXBP0_3 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_104 WLA1_104 WLB0_104 WLB1_104 RAMTP1024X16WD2X2
XI121 DBLA DBLA_DUM0_245 DBLA_DUM1_247 DBLB NXAP0_4 NXAP1_7 NXBP0_4 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_105 WLA1_105 WLB0_105 WLB1_105 RAMTP1024X16WD2X2
XI122 DBLA DBLA_DUM0_253 DBLA_DUM1_255 DBLB NXAP0_4 NXAP1_7 NXBP0_4 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_106 WLA1_106 WLB0_106 WLB1_106 RAMTP1024X16WD2X2
XI123 DBLA DBLA_DUM0_261 DBLA_DUM1_263 DBLB NXAP0_5 NXAP1_7 NXBP0_5 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_107 WLA1_107 WLB0_107 WLB1_107 RAMTP1024X16WD2X2
XI124 DBLA DBLA_DUM0_269 DBLA_DUM1_271 DBLB NXAP0_5 NXAP1_7 NXBP0_5 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_108 WLA1_108 WLB0_108 WLB1_108 RAMTP1024X16WD2X2
XI125 DBLA DBLA_DUM0_277 DBLA_DUM1_279 DBLB NXAP0_6 NXAP1_7 NXBP0_6 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_109 WLA1_109 WLB0_109 WLB1_109 RAMTP1024X16WD2X2
XI126 DBLA DBLA_DUM0_285 DBLA_DUM1_287 DBLB NXAP0_6 NXAP1_7 NXBP0_6 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_110 WLA1_110 WLB0_110 WLB1_110 RAMTP1024X16WD2X2
XI127 DBLA DBLA_DUM0_293 DBLA_DUM1_295 DBLB NXAP0_7 NXAP1_7 NXBP0_7 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_111 WLA1_111 WLB0_111 WLB1_111 RAMTP1024X16WD2X2
XI16 DBLA DBLA_DUM0_325 DBLA_DUM1_327 DBLB NXAP0_0 NXAP1_1 NXBP0_0 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_1 WLA1_1 WLB0_1 WLB1_1 RAMTP1024X16WD2X2
XI17 DBLA DBLA_DUM0_341 DBLA_DUM1_343 DBLB NXAP0_0 NXAP1_1 NXBP0_0 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_2 WLA1_2 WLB0_2 WLB1_2 RAMTP1024X16WD2X2
XI18 DBLA DBLA_DUM0_357 DBLA_DUM1_359 DBLB NXAP0_1 NXAP1_1 NXBP0_1 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_3 WLA1_3 WLB0_3 WLB1_3 RAMTP1024X16WD2X2
XI19 DBLA DBLA_DUM0_377 DBLA_DUM1_379 DBLB NXAP0_1 NXAP1_1 NXBP0_1 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_4 WLA1_4 WLB0_4 WLB1_4 RAMTP1024X16WD2X2
XI20 DBLA DBLA_DUM0_69 DBLA_DUM1_71 DBLB NXAP0_2 NXAP1_1 NXBP0_2 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_5 WLA1_5 WLB0_5 WLB1_5 RAMTP1024X16WD2X2
XI21 DBLA DBLA_DUM0_73 DBLA_DUM1_75 DBLB NXAP0_2 NXAP1_1 NXBP0_2 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_6 WLA1_6 WLB0_6 WLB1_6 RAMTP1024X16WD2X2
XI22 DBLA DBLA_DUM0_77 DBLA_DUM1_79 DBLB NXAP0_3 NXAP1_1 NXBP0_3 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_7 WLA1_7 WLB0_7 WLB1_7 RAMTP1024X16WD2X2
XI23 DBLA DBLA_DUM0_85 DBLA_DUM1_87 DBLB NXAP0_3 NXAP1_1 NXBP0_3 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_8 WLA1_8 WLB0_8 WLB1_8 RAMTP1024X16WD2X2
XI24 DBLA DBLA_DUM0_93 DBLA_DUM1_95 DBLB NXAP0_4 NXAP1_1 NXBP0_4 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_9 WLA1_9 WLB0_9 WLB1_9 RAMTP1024X16WD2X2
XI25 DBLA DBLA_DUM0_105 DBLA_DUM1_107 DBLB NXAP0_4 NXAP1_1 NXBP0_4 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_10 WLA1_10 WLB0_10 WLB1_10 RAMTP1024X16WD2X2
XI26 DBLA DBLA_DUM0_117 DBLA_DUM1_119 DBLB NXAP0_5 NXAP1_1 NXBP0_5 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_11 WLA1_11 WLB0_11 WLB1_11 RAMTP1024X16WD2X2
XI27 DBLA DBLA_DUM0_133 DBLA_DUM1_135 DBLB NXAP0_5 NXAP1_1 NXBP0_5 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_12 WLA1_12 WLB0_12 WLB1_12 RAMTP1024X16WD2X2
XI28 DBLA DBLA_DUM0_149 DBLA_DUM1_151 DBLB NXAP0_6 NXAP1_1 NXBP0_6 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_13 WLA1_13 WLB0_13 WLB1_13 RAMTP1024X16WD2X2
XI29 DBLA DBLA_DUM0_161 DBLA_DUM1_163 DBLB NXAP0_6 NXAP1_1 NXBP0_6 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_14 WLA1_14 WLB0_14 WLB1_14 RAMTP1024X16WD2X2
XI30 DBLA DBLA_DUM0_297 DBLA_DUM1_299 DBLB NXAP0_7 NXAP1_1 NXBP0_7 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_15 WLA1_15 WLB0_15 WLB1_15 RAMTP1024X16WD2X2
XI31 DBLA DBLA_DUM0_301 DBLA_DUM1_303 DBLB NXAP0_7 NXAP1_1 NXBP0_7 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_16 WLA1_16 WLB0_16 WLB1_16 RAMTP1024X16WD2X2
XI32 DBLA DBLA_DUM0_305 DBLA_DUM1_307 DBLB NXAP0_0 NXAP1_2 NXBP0_0 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_17 WLA1_17 WLB0_17 WLB1_17 RAMTP1024X16WD2X2
XI33 DBLA DBLA_DUM0_317 DBLA_DUM1_319 DBLB NXAP0_0 NXAP1_2 NXBP0_0 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_18 WLA1_18 WLB0_18 WLB1_18 RAMTP1024X16WD2X2
XI34 DBLA DBLA_DUM0_329 DBLA_DUM1_331 DBLB NXAP0_1 NXAP1_2 NXBP0_1 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_19 WLA1_19 WLB0_19 WLB1_19 RAMTP1024X16WD2X2
XI35 DBLA DBLA_DUM0_345 DBLA_DUM1_347 DBLB NXAP0_1 NXAP1_2 NXBP0_1 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_20 WLA1_20 WLB0_20 WLB1_20 RAMTP1024X16WD2X2
XI36 DBLA DBLA_DUM0_361 DBLA_DUM1_363 DBLB NXAP0_2 NXAP1_2 NXBP0_2 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_21 WLA1_21 WLB0_21 WLB1_21 RAMTP1024X16WD2X2
XI37 DBLA DBLA_DUM0_381 DBLA_DUM1_383 DBLB NXAP0_2 NXAP1_2 NXBP0_2 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_22 WLA1_22 WLB0_22 WLB1_22 RAMTP1024X16WD2X2
XI38 DBLA DBLA_DUM0_397 DBLA_DUM1_399 DBLB NXAP0_3 NXAP1_2 NXBP0_3 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_23 WLA1_23 WLB0_23 WLB1_23 RAMTP1024X16WD2X2
XI39 DBLA DBLA_DUM0_413 DBLA_DUM1_415 DBLB NXAP0_3 NXAP1_2 NXBP0_3 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_24 WLA1_24 WLB0_24 WLB1_24 RAMTP1024X16WD2X2
XI40 DBLA DBLA_DUM0_81 DBLA_DUM1_83 DBLB NXAP0_4 NXAP1_2 NXBP0_4 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_25 WLA1_25 WLB0_25 WLB1_25 RAMTP1024X16WD2X2
XI41 DBLA DBLA_DUM0_89 DBLA_DUM1_91 DBLB NXAP0_4 NXAP1_2 NXBP0_4 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_26 WLA1_26 WLB0_26 WLB1_26 RAMTP1024X16WD2X2
XI42 DBLA DBLA_DUM0_97 DBLA_DUM1_99 DBLB NXAP0_5 NXAP1_2 NXBP0_5 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_27 WLA1_27 WLB0_27 WLB1_27 RAMTP1024X16WD2X2
XI43 DBLA DBLA_DUM0_109 DBLA_DUM1_111 DBLB NXAP0_5 NXAP1_2 NXBP0_5 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_28 WLA1_28 WLB0_28 WLB1_28 RAMTP1024X16WD2X2
XI44 DBLA DBLA_DUM0_121 DBLA_DUM1_123 DBLB NXAP0_6 NXAP1_2 NXBP0_6 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_29 WLA1_29 WLB0_29 WLB1_29 RAMTP1024X16WD2X2
XI45 DBLA DBLA_DUM0_137 DBLA_DUM1_139 DBLB NXAP0_6 NXAP1_2 NXBP0_6 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_30 WLA1_30 WLB0_30 WLB1_30 RAMTP1024X16WD2X2
XI46 DBLA DBLA_DUM0_153 DBLA_DUM1_155 DBLB NXAP0_7 NXAP1_2 NXBP0_7 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_31 WLA1_31 WLB0_31 WLB1_31 RAMTP1024X16WD2X2
XI47 DBLA DBLA_DUM0_165 DBLA_DUM1_167 DBLB NXAP0_7 NXAP1_2 NXBP0_7 NXBP1_2
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_32 WLA1_32 WLB0_32 WLB1_32 RAMTP1024X16WD2X2
XI48 DBLA DBLA_DUM0_177 DBLA_DUM1_179 DBLB NXAP0_0 NXAP1_3 NXBP0_0 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_33 WLA1_33 WLB0_33 WLB1_33 RAMTP1024X16WD2X2
XI49 DBLA DBLA_DUM0_189 DBLA_DUM1_191 DBLB NXAP0_0 NXAP1_3 NXBP0_0 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_34 WLA1_34 WLB0_34 WLB1_34 RAMTP1024X16WD2X2
XI50 DBLA DBLA_DUM0_309 DBLA_DUM1_311 DBLB NXAP0_1 NXAP1_3 NXBP0_1 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_35 WLA1_35 WLB0_35 WLB1_35 RAMTP1024X16WD2X2
XI51 DBLA DBLA_DUM0_321 DBLA_DUM1_323 DBLB NXAP0_1 NXAP1_3 NXBP0_1 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_36 WLA1_36 WLB0_36 WLB1_36 RAMTP1024X16WD2X2
XI52 DBLA DBLA_DUM0_333 DBLA_DUM1_335 DBLB NXAP0_2 NXAP1_3 NXBP0_2 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_37 WLA1_37 WLB0_37 WLB1_37 RAMTP1024X16WD2X2
XI53 DBLA DBLA_DUM0_349 DBLA_DUM1_351 DBLB NXAP0_2 NXAP1_3 NXBP0_2 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_38 WLA1_38 WLB0_38 WLB1_38 RAMTP1024X16WD2X2
XI54 DBLA DBLA_DUM0_365 DBLA_DUM1_367 DBLB NXAP0_3 NXAP1_3 NXBP0_3 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_39 WLA1_39 WLB0_39 WLB1_39 RAMTP1024X16WD2X2
XI55 DBLA DBLA_DUM0_385 DBLA_DUM1_387 DBLB NXAP0_3 NXAP1_3 NXBP0_3 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_40 WLA1_40 WLB0_40 WLB1_40 RAMTP1024X16WD2X2
XI56 DBLA DBLA_DUM0_401 DBLA_DUM1_403 DBLB NXAP0_4 NXAP1_3 NXBP0_4 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_41 WLA1_41 WLB0_41 WLB1_41 RAMTP1024X16WD2X2
XI57 DBLA DBLA_DUM0_417 DBLA_DUM1_419 DBLB NXAP0_4 NXAP1_3 NXBP0_4 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_42 WLA1_42 WLB0_42 WLB1_42 RAMTP1024X16WD2X2
XI58 DBLA DBLA_DUM0_429 DBLA_DUM1_431 DBLB NXAP0_5 NXAP1_3 NXBP0_5 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_43 WLA1_43 WLB0_43 WLB1_43 RAMTP1024X16WD2X2
XI59 DBLA DBLA_DUM0_441 DBLA_DUM1_443 DBLB NXAP0_5 NXAP1_3 NXBP0_5 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_44 WLA1_44 WLB0_44 WLB1_44 RAMTP1024X16WD2X2
XI60 DBLA DBLA_DUM0_101 DBLA_DUM1_103 DBLB NXAP0_6 NXAP1_3 NXBP0_6 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_45 WLA1_45 WLB0_45 WLB1_45 RAMTP1024X16WD2X2
XI61 DBLA DBLA_DUM0_113 DBLA_DUM1_115 DBLB NXAP0_6 NXAP1_3 NXBP0_6 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_46 WLA1_46 WLB0_46 WLB1_46 RAMTP1024X16WD2X2
XI62 DBLA DBLA_DUM0_125 DBLA_DUM1_127 DBLB NXAP0_7 NXAP1_3 NXBP0_7 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_47 WLA1_47 WLB0_47 WLB1_47 RAMTP1024X16WD2X2
XI63 DBLA DBLA_DUM0_141 DBLA_DUM1_143 DBLB NXAP0_7 NXAP1_3 NXBP0_7 NXBP1_3
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_48 WLA1_48 WLB0_48 WLB1_48 RAMTP1024X16WD2X2
XI64 DBLA DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RETA RETB ROWCLK0A ROWCLK0B
+  ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDC VDDC
+  VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0 VDDC_FDECB0 VDDC_FDECB0
+  VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW VPW
+  RAMTP1024X16WD2X2STRAP
XI65 DBLA DBLA_DUM0_169 DBLA_DUM1_171 DBLB NXAP0_0 NXAP1_4 NXBP0_0 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_49 WLA1_49 WLB0_49 WLB1_49 RAMTP1024X16WD2X2
XI66 DBLA DBLA_DUM0_181 DBLA_DUM1_183 DBLB NXAP0_0 NXAP1_4 NXBP0_0 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_50 WLA1_50 WLB0_50 WLB1_50 RAMTP1024X16WD2X2
XI67 DBLA DBLA_DUM0_193 DBLA_DUM1_195 DBLB NXAP0_1 NXAP1_4 NXBP0_1 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_51 WLA1_51 WLB0_51 WLB1_51 RAMTP1024X16WD2X2
XI68 DBLA DBLA_DUM0_201 DBLA_DUM1_203 DBLB NXAP0_1 NXAP1_4 NXBP0_1 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_52 WLA1_52 WLB0_52 WLB1_52 RAMTP1024X16WD2X2
XI69 DBLA DBLA_DUM0_209 DBLA_DUM1_211 DBLB NXAP0_2 NXAP1_4 NXBP0_2 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_53 WLA1_53 WLB0_53 WLB1_53 RAMTP1024X16WD2X2
XI70 DBLA DBLA_DUM0_337 DBLA_DUM1_339 DBLB NXAP0_2 NXAP1_4 NXBP0_2 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_54 WLA1_54 WLB0_54 WLB1_54 RAMTP1024X16WD2X2
XI71 DBLA DBLA_DUM0_353 DBLA_DUM1_355 DBLB NXAP0_3 NXAP1_4 NXBP0_3 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_55 WLA1_55 WLB0_55 WLB1_55 RAMTP1024X16WD2X2
XI72 DBLA DBLA_DUM0_369 DBLA_DUM1_371 DBLB NXAP0_3 NXAP1_4 NXBP0_3 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_56 WLA1_56 WLB0_56 WLB1_56 RAMTP1024X16WD2X2
XI73 DBLA DBLA_DUM0_389 DBLA_DUM1_391 DBLB NXAP0_4 NXAP1_4 NXBP0_4 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_57 WLA1_57 WLB0_57 WLB1_57 RAMTP1024X16WD2X2
XI74 DBLA DBLA_DUM0_405 DBLA_DUM1_407 DBLB NXAP0_4 NXAP1_4 NXBP0_4 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_58 WLA1_58 WLB0_58 WLB1_58 RAMTP1024X16WD2X2
XI75 DBLA DBLA_DUM0_421 DBLA_DUM1_423 DBLB NXAP0_5 NXAP1_4 NXBP0_5 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_59 WLA1_59 WLB0_59 WLB1_59 RAMTP1024X16WD2X2
XI76 DBLA DBLA_DUM0_433 DBLA_DUM1_435 DBLB NXAP0_5 NXAP1_4 NXBP0_5 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_60 WLA1_60 WLB0_60 WLB1_60 RAMTP1024X16WD2X2
XI77 DBLA DBLA_DUM0_445 DBLA_DUM1_447 DBLB NXAP0_6 NXAP1_4 NXBP0_6 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_61 WLA1_61 WLB0_61 WLB1_61 RAMTP1024X16WD2X2
XI78 DBLA DBLA_DUM0_453 DBLA_DUM1_455 DBLB NXAP0_6 NXAP1_4 NXBP0_6 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_62 WLA1_62 WLB0_62 WLB1_62 RAMTP1024X16WD2X2
XI79 DBLA DBLA_DUM0_461 DBLA_DUM1_463 DBLB NXAP0_7 NXAP1_4 NXBP0_7 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_63 WLA1_63 WLB0_63 WLB1_63 RAMTP1024X16WD2X2
XI80 DBLA DBLA_DUM0_129 DBLA_DUM1_131 DBLB NXAP0_7 NXAP1_4 NXBP0_7 NXBP1_4
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_64 WLA1_64 WLB0_64 WLB1_64 RAMTP1024X16WD2X2
XI81 DBLA DBLA_DUM0_145 DBLA_DUM1_147 DBLB NXAP0_0 NXAP1_5 NXBP0_0 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_65 WLA1_65 WLB0_65 WLB1_65 RAMTP1024X16WD2X2
XI82 DBLA DBLA_DUM0_157 DBLA_DUM1_159 DBLB NXAP0_0 NXAP1_5 NXBP0_0 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_66 WLA1_66 WLB0_66 WLB1_66 RAMTP1024X16WD2X2
XI83 DBLA DBLA_DUM0_173 DBLA_DUM1_175 DBLB NXAP0_1 NXAP1_5 NXBP0_1 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_67 WLA1_67 WLB0_67 WLB1_67 RAMTP1024X16WD2X2
XI84 DBLA DBLA_DUM0_185 DBLA_DUM1_187 DBLB NXAP0_1 NXAP1_5 NXBP0_1 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_68 WLA1_68 WLB0_68 WLB1_68 RAMTP1024X16WD2X2
XI85 DBLA DBLA_DUM0_197 DBLA_DUM1_199 DBLB NXAP0_2 NXAP1_5 NXBP0_2 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_69 WLA1_69 WLB0_69 WLB1_69 RAMTP1024X16WD2X2
XI86 DBLA DBLA_DUM0_205 DBLA_DUM1_207 DBLB NXAP0_2 NXAP1_5 NXBP0_2 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_70 WLA1_70 WLB0_70 WLB1_70 RAMTP1024X16WD2X2
XI87 DBLA DBLA_DUM0_213 DBLA_DUM1_215 DBLB NXAP0_3 NXAP1_5 NXBP0_3 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_71 WLA1_71 WLB0_71 WLB1_71 RAMTP1024X16WD2X2
XI88 DBLA DBLA_DUM0_217 DBLA_DUM1_219 DBLB NXAP0_3 NXAP1_5 NXBP0_3 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_72 WLA1_72 WLB0_72 WLB1_72 RAMTP1024X16WD2X2
XI89 DBLA DBLA_DUM0_221 DBLA_DUM1_223 DBLB NXAP0_4 NXAP1_5 NXBP0_4 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_73 WLA1_73 WLB0_73 WLB1_73 RAMTP1024X16WD2X2
XI90 DBLA DBLA_DUM0_373 DBLA_DUM1_375 DBLB NXAP0_4 NXAP1_5 NXBP0_4 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_74 WLA1_74 WLB0_74 WLB1_74 RAMTP1024X16WD2X2
XI91 DBLA DBLA_DUM0_393 DBLA_DUM1_395 DBLB NXAP0_5 NXAP1_5 NXBP0_5 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_75 WLA1_75 WLB0_75 WLB1_75 RAMTP1024X16WD2X2
XI92 DBLA DBLA_DUM0_409 DBLA_DUM1_411 DBLB NXAP0_5 NXAP1_5 NXBP0_5 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_76 WLA1_76 WLB0_76 WLB1_76 RAMTP1024X16WD2X2
XI93 DBLA DBLA_DUM0_425 DBLA_DUM1_427 DBLB NXAP0_6 NXAP1_5 NXBP0_6 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_77 WLA1_77 WLB0_77 WLB1_77 RAMTP1024X16WD2X2
XI94 DBLA DBLA_DUM0_437 DBLA_DUM1_439 DBLB NXAP0_6 NXAP1_5 NXBP0_6 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_78 WLA1_78 WLB0_78 WLB1_78 RAMTP1024X16WD2X2
XI95 DBLA DBLA_DUM0_449 DBLA_DUM1_451 DBLB NXAP0_7 NXAP1_5 NXBP0_7 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_79 WLA1_79 WLB0_79 WLB1_79 RAMTP1024X16WD2X2
XI96 DBLA DBLA_DUM0_457 DBLA_DUM1_459 DBLB NXAP0_7 NXAP1_5 NXBP0_7 NXBP1_5
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_80 WLA1_80 WLB0_80 WLB1_80 RAMTP1024X16WD2X2
XI97 DBLA DBLA_DUM0_465 DBLA_DUM1_467 DBLB NXAP0_0 NXAP1_6 NXBP0_0 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_81 WLA1_81 WLB0_81 WLB1_81 RAMTP1024X16WD2X2
XI98 DBLA DBLA_DUM0_469 DBLA_DUM1_471 DBLB NXAP0_0 NXAP1_6 NXBP0_0 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_82 WLA1_82 WLB0_82 WLB1_82 RAMTP1024X16WD2X2
XI99 DBLA DBLA_DUM0_473 DBLA_DUM1_475 DBLB NXAP0_1 NXAP1_6 NXBP0_1 NXBP1_6
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_83 WLA1_83 WLB0_83 WLB1_83 RAMTP1024X16WD2X2
XTOPWD DBLA DBLA_DUM0_313 DBLA_DUM1_315 DBLB NXAP0_7 NXAP1_7 NXBP0_7 NXBP1_7
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_112 WLA1_112 WLB0_112 WLB1_112 RAMTP1024X16WD2X2
XTOPWDEND DBLA DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RETA RETB ROWCLK0A ROWCLK0B
+  ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC
+  VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECA0 VDDC_FDECB0 VDDC_FDECB0
+  VDDC_FDECB0 VDDC_FDECB0 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC
+  VDDPE VPW VPW VPW RAMTP1024X16WD2X2TOP
.ENDS RAMTP1024X16WD_STACK
****
.SUBCKT RAMTP1024X16WD_STACKCAP DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1]
+  EMAA[2] EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1]
+  LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A LOG1B RAA[0] RAA[1] RAA[2] RAA[3]
+  RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC
+  VDDPE VSSE WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8
+  WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17
+  WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26
+  WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35
+  WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44
+  WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53
+  WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62
+  WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71
+  WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80
+  WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89
+  WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98
+  WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106
+  WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114
+  WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122
+  WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2 WLA1_3
+  WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13
+  WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22
+  WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31
+  WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40
+  WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49
+  WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58
+  WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66 WLA1_67
+  WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75 WLA1_76
+  WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84 WLA1_85
+  WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93 WLA1_94
+  WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102 WLA1_103
+  WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110 WLA1_111
+  WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118 WLA1_119
+  WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126 WLA1_127
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36
+  WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45
+  WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54
+  WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63
+  WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72
+  WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81
+  WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90
+  WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99
+  WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107
+  WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115
+  WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123
+  WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4
+  WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14
+  WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23
+  WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32
+  WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41
+  WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50
+  WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59
+  WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68
+  WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77
+  WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86
+  WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95
+  WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119
+  WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16WD_STACKCAP: 6047 flat devices **
XWD_STACK DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1]
+  EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA
+  LOG0_DWLB LOG1A LOG1B VSSE VSSE RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5]
+  RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC VDDC_FDECA0
+  VDDC_FDECB0 VDDPE VSSE WLA0_0 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20
+  WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29
+  WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38
+  WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47
+  WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56
+  WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65
+  WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74
+  WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83
+  WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92
+  WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101
+  WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109
+  WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117
+  WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125
+  WLA0_126 WLA0_127 WLA1_0 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21
+  WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30
+  WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39
+  WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48
+  WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57
+  WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66
+  WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75
+  WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84
+  WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93
+  WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102
+  WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110
+  WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118
+  WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126
+  WLA1_127 WLA0_1 WLA1_1 WLA0_2 WLA1_2 WLA0_3 WLA1_3 WLA0_4 WLA1_4 WLA0_5
+  WLA1_5 WLA0_6 WLA1_6 WLA0_7 WLA1_7 WLA0_8 WLA1_8 WLA0_9 WLA1_9 WLA0_10
+  WLA1_10 WLA0_11 WLA1_11 WLA0_12 WLA1_12 WLA0_13 WLA1_13 WLA0_14 WLA1_14
+  WLA0_15 WLA1_15 WLB0_0 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21
+  WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30
+  WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39
+  WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48
+  WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57
+  WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66
+  WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75
+  WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84
+  WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93
+  WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102
+  WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110
+  WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118
+  WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126
+  WLB0_127 WLB1_0 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40
+  WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49
+  WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58
+  WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67
+  WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76
+  WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85
+  WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94
+  WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119
+  WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127
+  WLB0_1 WLB1_1 WLB0_2 WLB1_2 WLB0_3 WLB1_3 WLB0_4 WLB1_4 WLB0_5 WLB1_5
+  WLB0_6 WLB1_6 WLB0_7 WLB1_7 WLB0_8 WLB1_8 WLB0_9 WLB1_9 WLB0_10 WLB1_10
+  WLB0_11 WLB1_11 WLB0_12 WLB1_12 WLB0_13 WLB1_13 WLB0_14 WLB1_14 WLB0_15
+  WLB1_15 RAMTP1024X16WD_STACK
.ENDS RAMTP1024X16WD_STACKCAP
****
.SUBCKT RAMTP1024X16WRM4_WM D RD VDDCE VDDPE VNWP VPW VSS VSSE WCLK WEN WENL
+  WENR WRONE WRZERO
** RAMTP1024X16WRM4_WM: 48 flat devices **
X_MI1.MXNA1 DWE_LAT NET0113 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI1.MXNA2 DWE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI1.MXPA1 DWE_LAT NET0113 I1.P1 VNWP P11LL_CKT W=0.44U L=0.04U
X_MI1.MXPA2 I1.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.44U L=0.04U
X_MI159.MXNA1 NWCLK WCLK VSS VPW N11LL_CKT W=0.165U L=0.04U
X_MI159.MXPA1 NWCLK WCLK VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI168.MXNA1 NET92 DWE_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI168.MXPA1 NET92 DWE_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI169.MXNA1 NET86 NDWE_LAT VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI169.MXPA1 NET86 NDWE_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI170.MXNA1 WE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.2U L=0.04U
X_MI170.MXPA1 WE_LAT WEN_LAT VDDPE VNWP P11LL_CKT W=0.325U L=0.04U
X_MI2.MXNA1 NDWE_LAT D_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI2.MXNA2 NDWE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI2.MXPA1 NDWE_LAT D_LAT I2.P1 VNWP P11LL_CKT W=0.44U L=0.04U
X_MI2.MXPA2 I2.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.44U L=0.04U
X_MI3.MXNA1 NET0113 D_LAT VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI3.MXPA1 NET0113 D_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIV_WrClk.MXNA1 IWCLK NWCLK VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MIV_WrClk.MXPA1 IWCLK NWCLK VDDPE VNWP P11LL_CKT W=0.325U L=0.04U
X_MXN0 WRONE NDWE_LAT VSS VPW N11LL_CKT W=2.12U L=0.04U
X_MXN2 WRZERO DWE_LAT VSS VPW N11LL_CKT W=2.12U L=0.04U
X_MXP0 WRONE NET92 VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MXP2 WRZERO NET86 VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MXP3 NET22 IWCLK VDDPE VNWP P11LL_CKT W=0.49U L=0.04U
X_MXP5 WRONE WE_LAT NET22 VNWP P11LL_CKT W=0.49U L=0.04U
X_MXP6 NET30 IWCLK VDDPE VNWP P11LL_CKT W=0.49U L=0.04U
X_MXP7 WRZERO WE_LAT NET30 VNWP P11LL_CKT W=0.49U L=0.04U
X_M_dlat.I47.MXNA1 _DLAT.ND D VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I47.MXPA1 _DLAT.ND D VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.I48.MXNOE DLAT_NQ NWCLK _DLAT.ND VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I48.MXPOEN DLAT_NQ IWCLK _DLAT.ND VNWP P11LL_CKT W=0.15U L=0.04U
X_M_dlat.I50.MXNA1 D_LAT DLAT_NQ VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I50.MXPA1 D_LAT DLAT_NQ VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.I55.MXNA1 _DLAT.I55.N1 D_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXNOE DLAT_NQ IWCLK _DLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXPA1 _DLAT.I55.P1 D_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXPOEN DLAT_NQ NWCLK _DLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I47.MXNA1 _WENLAT.ND WEN VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I47.MXPA1 _WENLAT.ND WEN VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_wenlat.I48.MXNOE WENLAT_NQ NWCLK _WENLAT.ND VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I48.MXPOEN WENLAT_NQ IWCLK _WENLAT.ND VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I50.MXNA1 WEN_LAT WENLAT_NQ VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I50.MXPA1 WEN_LAT WENLAT_NQ VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_wenlat.I55.MXNA1 _WENLAT.I55.N1 WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I55.MXNOE WENLAT_NQ IWCLK _WENLAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I55.MXPA1 _WENLAT.I55.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I55.MXPOEN WENLAT_NQ NWCLK _WENLAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
.ENDS RAMTP1024X16WRM4_WM
****
.SUBCKT RAMTP1024X16WR_COLX_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 RD_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE VPW VSS WCLK WENR WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WRONE_0 WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7
+  WRZERO_0 WRZERO_1 WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7
** RAMTP1024X16WR_COLX_L: 384 flat devices **
XWR_1 D_1 RD_1 VDDCE_1 VDDPE VDDPE VPW VSS VSS WCLK WEN_1 WEN_1 WEN_2 WRONE_1
+  WRZERO_1 RAMTP1024X16WRM4_WM
XWR_2 D_2 RD_2 VDDCE_2 VDDPE VDDPE VPW VSS VSS WCLK WEN_2 WEN_2 WEN_3 WRONE_2
+  WRZERO_2 RAMTP1024X16WRM4_WM
XWR_3 D_3 RD_3 VDDCE_3 VDDPE VDDPE VPW VSS VSS WCLK WEN_3 WEN_3 WEN_4 WRONE_3
+  WRZERO_3 RAMTP1024X16WRM4_WM
XWR_4 D_4 RD_4 VDDCE_4 VDDPE VDDPE VPW VSS VSS WCLK WEN_4 WEN_4 WEN_5 WRONE_4
+  WRZERO_4 RAMTP1024X16WRM4_WM
XWR_5 D_5 RD_5 VDDCE_5 VDDPE VDDPE VPW VSS VSS WCLK WEN_5 WEN_5 WEN_6 WRONE_5
+  WRZERO_5 RAMTP1024X16WRM4_WM
XWR_6 D_6 RD_6 VDDCE_6 VDDPE VDDPE VPW VSS VSS WCLK WEN_6 WEN_6 WENR WRONE_6
+  WRZERO_6 RAMTP1024X16WRM4_WM
XWR_FARWD D_7 RD_7 VDDCE_7 VDDPE VDDPE VPW VSS VSS WCLK WENR WENR WENR WRONE_7
+  WRZERO_7 RAMTP1024X16WRM4_WM
XWR_NEARWD D_0 RD_0 VDDCE_0 VDDPE VDDPE VPW VSS VSS WCLK WEN_0 WEN_0 WEN_1
+  WRONE_0 WRZERO_0 RAMTP1024X16WRM4_WM
.ENDS RAMTP1024X16WR_COLX_L
****
.SUBCKT RAMTP1024X16RDM4 D Q RD0 TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN
+  WENY
** RAMTP1024X16RDM4: 2 flat devices **
X_MIV_Q.MXNA1 Q RD0 VSS VPW N11LL_CKT W=2U L=0.04U
X_MIV_Q.MXPA1 Q RD0 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
.ENDS RAMTP1024X16RDM4
****
.SUBCKT RAMTP1024X16RD_COLX_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 RD0_0 RD0_1 RD0_2 RD0_3 RD0_4 RD0_5 RD0_6 RD0_7 TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDPE VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0
+  VPW_1 VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSSE_0 VSSE_1 VSSE_2 VSSE_3
+  VSSE_4 VSSE_5 VSSE_6 VSSE_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7
+  WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2
+  WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP1024X16RD_COLX_L: 16 flat devices **
XRD_1 D_1 Q_1 RD0_1 TD_1 TWEN_1 VDDCE_1 VDDPE VNWP_1 VPW_1 VSS_1 VSSE_1 WEN_1
+  WENY_1 RAMTP1024X16RDM4
XRD_2 D_2 Q_2 RD0_2 TD_2 TWEN_2 VDDCE_2 VDDPE VNWP_2 VPW_2 VSS_2 VSSE_2 WEN_2
+  WENY_2 RAMTP1024X16RDM4
XRD_3 D_3 Q_3 RD0_3 TD_3 TWEN_3 VDDCE_3 VDDPE VNWP_3 VPW_3 VSS_3 VSSE_3 WEN_3
+  WENY_3 RAMTP1024X16RDM4
XRD_4 D_4 Q_4 RD0_4 TD_4 TWEN_4 VDDCE_4 VDDPE VNWP_4 VPW_4 VSS_4 VSSE_4 WEN_4
+  WENY_4 RAMTP1024X16RDM4
XRD_5 D_5 Q_5 RD0_5 TD_5 TWEN_5 VDDCE_5 VDDPE VNWP_5 VPW_5 VSS_5 VSSE_5 WEN_5
+  WENY_5 RAMTP1024X16RDM4
XRD_6 D_6 Q_6 RD0_6 TD_6 TWEN_6 VDDCE_6 VDDPE VNWP_6 VPW_6 VSS_6 VSSE_6 WEN_6
+  WENY_6 RAMTP1024X16RDM4
XRD_FARWD D_7 Q_7 RD0_7 TD_7 TWEN_7 VDDCE_7 VDDPE VNWP_7 VPW_7 VSS_7 VSSE_7
+  WEN_7 WENY_7 RAMTP1024X16RDM4
XRD_NEARWD D_0 Q_0 RD0_0 TD_0 TWEN_0 VDDCE_0 VDDPE VNWP_0 VPW_0 VSS_0 VSSE_0
+  WEN_0 WENY_0 RAMTP1024X16RDM4
.ENDS RAMTP1024X16RD_COLX_L
****
.SUBCKT RAMTP1024X16CDM4EDGE_BST DFT DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYP2A_TERM NYP2B_TERM NYP3A_TERM
+  NYP3B_TERM NYPCOL0 NYPCOL1 NYPCOL2 NYPCOL3 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SIA SIB SOA SOB TIELO VDDCE VDDPE VNWC VNWP VPW VSS VSSE
** RAMTP1024X16CDM4EDGE_BST: 10 flat devices **
X_MI0.MXNA1 NET68 NET44 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI0.MXPA1 NET68 NET44 VDDPE VNWC P11LL_CKT W=0.24U L=0.04U
X_MI1.MXNA1 NET44 SIA VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI1.MXPA1 NET44 SIA VDDPE VNWC P11LL_CKT W=0.145U L=0.04U
X_MI17.MXNA1 SOA NET68 VSS VPW N11LL_CKT W=0.54U L=0.04U
X_MI17.MXPA1 SOA NET68 VDDPE VNWC P11LL_CKT W=1.08U L=0.04U
X_MI2.MXNA1 SOB NET56 VSS VPW N11LL_CKT W=0.54U L=0.04U
X_MI2.MXPA1 SOB NET56 VDDPE VNWP P11LL_CKT W=1.08U L=0.04U
X_MI3.MXNA1 NET56 SIB VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI3.MXPA1 NET56 SIB VDDPE VNWP P11LL_CKT W=0.24U L=0.04U
.ENDS RAMTP1024X16CDM4EDGE_BST
****
.SUBCKT RAMTP1024X16ENDBOT_COL_LT DFT DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYP2A_TERM NYP2B_TERM NYP3A_TERM
+  NYP3B_TERM NYPCOL0 NYPCOL1 NYPCOL2 NYPCOL3 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SIA TIELO_0 TIELO_1 VDDCE VDDPE_0 VDDPE_1 VDDPE_2 VNWC VNWP
+  VPW_0 VPW_1 VSSE VSS_0 VSS_1 WCLK WEN
** RAMTP1024X16ENDBOT_COL_LT: 10 flat devices **
XCDEDGECELL DFT DWL DWLTURN NSAE_TERM NYP0A_TERM NYP0B_TERM NYP1A_TERM
+  NYP1B_TERM NYP2A_TERM NYP2B_TERM NYP3A_TERM NYP3B_TERM NYPCOL0 NYPCOL1
+  NYPCOL2 NYPCOL3 PRECHA_TERM PRECHB_TERM SAPRECH_TERM SIA TIELO_0 SOA SOB
+  TIELO_1 VDDCE VDDPE_0 VNWC VDDPE_0 VPW_0 VSS_1 VSSE
+  RAMTP1024X16CDM4EDGE_BST
.ENDS RAMTP1024X16ENDBOT_COL_LT
****
.SUBCKT RAMTP1024X16CDM4_BST BLA0 BLA1 BLA2 BLA3 BLB0 BLB1 BLB2 BLB3 DFT DWL
+  DWLTURN NBLA0 NBLA1 NBLA2 NBLA3 NBLB0 NBLB1 NBLB2 NBLB3 NSAE NWRDATA
+  NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD SAPRECH SI SO TIELO
+  VDDC VDDCE VDDPE VNWC VNWP VPW VSS VSSE WRDATA YPCLK0B YPCLK1B YPCLK2B
+  YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16CDM4_BST: 125 flat devices **
X_M_cd_01.I62.MXNA1 _CD_01.NPRECHA PRECHA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_01.I62.MXPA1 _CD_01.NPRECHA PRECHA VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_01.I80.MXNA1 _CD_01.NPRECHB PRECHB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_01.I80.MXPA1 _CD_01.NPRECHB PRECHB VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_01._cmuxa0.MXP0 NSD NYPCLK0A BLA0 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa0.MXP91 NBLA0 NYPCLK0A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa0.MXPEQ BLA0 _CD_01.NPRECHA NBLA0 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa0.MXPPU0 NBLA0 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa0.MXPPU1 BLA0 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXP0 NSD NYPCLK1A BLA1 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa1.MXP91 NBLA1 NYPCLK1A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa1.MXPEQ BLA1 _CD_01.NPRECHA NBLA1 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXPPU0 NBLA1 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXPPU1 BLA1 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.IV_Mux.MXNA1 _CD_01._CMUXB0.NYP YPCLK0B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_01._cmuxb0.IV_Mux.MXPA1 _CD_01._CMUXB0.NYP YPCLK0B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_01._cmuxb0.MXPEQ BLB0 _CD_01.NPRECHB NBLB0 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.MXPPU0 NBLB0 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.MXPPU1 BLB0 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.TG0.MXNOE NBLB0 YPCLK0B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_01._cmuxb0.TG0.MXPOEN NBLB0 _CD_01._CMUXB0.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb0.TG1.MXNOE BLB0 YPCLK0B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_01._cmuxb0.TG1.MXPOEN BLB0 _CD_01._CMUXB0.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb1.IV_Mux.MXNA1 _CD_01._CMUXB1.NYP YPCLK1B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_01._cmuxb1.IV_Mux.MXPA1 _CD_01._CMUXB1.NYP YPCLK1B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_01._cmuxb1.MXPEQ BLB1 _CD_01.NPRECHB NBLB1 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.MXPPU0 NBLB1 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.MXPPU1 BLB1 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.TG0.MXNOE NBLB1 YPCLK1B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_01._cmuxb1.TG0.MXPOEN NBLB1 _CD_01._CMUXB1.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb1.TG1.MXNOE BLB1 YPCLK1B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_01._cmuxb1.TG1.MXPOEN BLB1 _CD_01._CMUXB1.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._collcmux0.MXN0 BLA0 YPCOLCLK0 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux0.MXN3 NBLA0 YPCOLCLK0 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux1.MXN0 BLA1 YPCOLCLK1 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux1.MXN3 NBLA1 YPCOLCLK1 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_23.I62.MXNA1 _CD_23.NPRECHA PRECHA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_23.I62.MXPA1 _CD_23.NPRECHA PRECHA VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_23.I80.MXNA1 _CD_23.NPRECHB PRECHB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_23.I80.MXPA1 _CD_23.NPRECHB PRECHB VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_23._cmuxa0.MXP0 NSD NYPCLK2A BLA2 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_23._cmuxa0.MXP91 NBLA2 NYPCLK2A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_23._cmuxa0.MXPEQ BLA2 _CD_23.NPRECHA NBLA2 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxa0.MXPPU0 NBLA2 _CD_23.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxa0.MXPPU1 BLA2 _CD_23.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxa1.MXP0 NSD NYPCLK3A BLA3 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_23._cmuxa1.MXP91 NBLA3 NYPCLK3A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_23._cmuxa1.MXPEQ BLA3 _CD_23.NPRECHA NBLA3 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxa1.MXPPU0 NBLA3 _CD_23.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxa1.MXPPU1 BLA3 _CD_23.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb0.IV_Mux.MXNA1 _CD_23._CMUXB0.NYP YPCLK2B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_23._cmuxb0.IV_Mux.MXPA1 _CD_23._CMUXB0.NYP YPCLK2B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_23._cmuxb0.MXPEQ BLB2 _CD_23.NPRECHB NBLB2 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb0.MXPPU0 NBLB2 _CD_23.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb0.MXPPU1 BLB2 _CD_23.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb0.TG0.MXNOE NBLB2 YPCLK2B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_23._cmuxb0.TG0.MXPOEN NBLB2 _CD_23._CMUXB0.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_23._cmuxb0.TG1.MXNOE BLB2 YPCLK2B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_23._cmuxb0.TG1.MXPOEN BLB2 _CD_23._CMUXB0.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_23._cmuxb1.IV_Mux.MXNA1 _CD_23._CMUXB1.NYP YPCLK3B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_23._cmuxb1.IV_Mux.MXPA1 _CD_23._CMUXB1.NYP YPCLK3B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_23._cmuxb1.MXPEQ BLB3 _CD_23.NPRECHB NBLB3 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb1.MXPPU0 NBLB3 _CD_23.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb1.MXPPU1 BLB3 _CD_23.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_23._cmuxb1.TG0.MXNOE NBLB3 YPCLK3B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_23._cmuxb1.TG0.MXPOEN NBLB3 _CD_23._CMUXB1.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_23._cmuxb1.TG1.MXNOE BLB3 YPCLK3B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_23._cmuxb1.TG1.MXPOEN BLB3 _CD_23._CMUXB1.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_23._collcmux0.MXN0 BLA2 YPCOLCLK2 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_23._collcmux0.MXN3 NBLA2 YPCOLCLK2 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_23._collcmux1.MXN0 BLA3 YPCOLCLK3 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_23._collcmux1.MXN3 NBLA3 YPCOLCLK3 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_dwl_load_0.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_0.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_0.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_2.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_2.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_2.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_3.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_3.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_3.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_sa.I1.MXNA1 _SA.NDFT _SA.NSAPRECH _SA.I1.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXNA2 _SA.I1.N1 DFT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXPA1 _SA.NDFT _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXPA2 _SA.NDFT DFT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_sa.I46.MXNA1 BSAE NSAE VSS VPW N11LL_CKT W=0.19U L=0.04U
X_M_sa.I46.MXPA1 BSAE NSAE VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_sa.I60.MXNA1 _SA.NSI SI VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_sa.I60.MXPA1 _SA.NSI SI VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_M_sa.MXN0 VSS TIELO VSS VPW N11LL_CKT W=0.96U L=0.08U
X_M_sa.MXP11 _SA.ISI BSAE SI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP12 SD _SA.NDFT _SA.ISI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP13 NSD _SA.NDFT _SA.NISI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP14 _SA.NISI BSAE _SA.NSI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa._mem_senseamp.MXN17 NSD SD _SA.NET051 VPW N11LL_CKT W=2.4U L=0.08U
X_M_sa._mem_senseamp.MXN18 _SA.NET051 BSAE VSS VPW N11LL_CKT W=1.2U L=0.04U
X_M_sa._mem_senseamp.MXN19 SD NSD _SA.NET051 VPW N11LL_CKT W=2.4U L=0.08U
X_M_sa._mem_senseamp.MXP24 NSD _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_sa._mem_senseamp.MXP25 NSD _SA.NSAPRECH SD VNWP P11LL_CKT W=0.4U L=0.04U
X_M_sa._mem_senseamp.MXP26 SD _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_M_sa._mem_senseamp.MXP27 NSD SD VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_sa._mem_senseamp.MXP28 SD NSD VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_sa._ndnsapre.MXN0 _SA._NDNSAPRE.NET15 NLAT_E VSS VPW N11LL_CKT W=0.48U
+  L=0.04U
X_M_sa._ndnsapre.MXN1 _SA.NSAPRECH SAPRECH _SA._NDNSAPRE.NET15 VPW N11LL_CKT
+  W=0.24U L=0.04U
X_M_sa._ndnsapre.MXP0 _SA.NSAPRECH NLAT_E VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_M_sa._ndnsapre.MXP12 _SA.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_salat.I62.MXNA1 RD _SALAT.SD_LAT VSS VPW N11LL_CKT W=0.485U L=0.04U
X_M_salat.I62.MXPA1 RD _SALAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.61U L=0.04U
X_M_salat.I63.MXNA1 _SALAT.IRD _SALAT.SD_LAT VSS VPW N11LL_CKT W=0.12U L=0.04U
X_M_salat.I63.MXPA1 _SALAT.IRD _SALAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.12U
+  L=0.04U
X_M_salat.I82.MXNA1 NLAT_E BSAE VSS VPW N11LL_CKT W=0.35U L=0.04U
X_M_salat.I82.MXPA1 NLAT_E BSAE VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_salat.MXN8 _SALAT.N1B _SALAT.IRD VSS VPW N11LL_CKT W=0.135U L=0.04U
X_M_salat.MXN9 _SALAT.SD_LAT NLAT_E _SALAT.N1B VPW N11LL_CKT W=0.135U L=0.04U
X_M_salat.MXP6 _SALAT.SD_LAT BSAE _SALAT.P1B VNWP P11LL_CKT W=0.16U L=0.04U
X_M_salat.MXP7 _SALAT.P1B _SALAT.IRD VDDPE VNWP P11LL_CKT W=0.16U L=0.04U
X_M_salat.MXPs _SALAT.SD_LAT SD _SALAT.P1A VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_ndmy _SALAT.NSD_DUM NSD _SALAT.N1A VPW N11LL_CKT W=0.27U L=0.04U
X_M_salat.MX_nlat _SALAT.N1A BSAE VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_salat.MX_pdmy _SALAT.NSD_DUM NSD _SALAT.P1A VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_pnsae _SALAT.P1A NLAT_E VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_sd_n _SALAT.SD_LAT SD _SALAT.N1A VPW N11LL_CKT W=0.27U L=0.04U
.ENDS RAMTP1024X16CDM4_BST
****
.SUBCKT RAMTP1024X16CD_COLXREG_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLA2_0 BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1
+  BLA3_2 BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5
+  BLB1_6 BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7
+  BLB3_0 BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2
+  NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3
+  NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6
+  NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4
+  WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0
+  YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16CD_COLXREG_LT: 1000 flat devices **
XCD_1 BLA0_1 BLA1_1 BLA2_1 BLA3_1 BLB0_1 BLB1_1 BLB2_1 BLB3_1 DFT DWL DWL
+  NBLA0_1 NBLA1_1 NBLA2_1 NBLA3_1 NBLB0_1 NBLB1_1 NBLB2_1 NBLB3_1 NSAE
+  NWRDATA_1 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_1 SAPRECH
+  RD_0 RD_1 TIELO VDDC_1 VDDCE_1 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_1
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_2 BLA0_2 BLA1_2 BLA2_2 BLA3_2 BLB0_2 BLB1_2 BLB2_2 BLB3_2 DFT DWL DWL
+  NBLA0_2 NBLA1_2 NBLA2_2 NBLA3_2 NBLB0_2 NBLB1_2 NBLB2_2 NBLB3_2 NSAE
+  NWRDATA_2 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_2 SAPRECH
+  RD_1 RD_2 TIELO VDDC_2 VDDCE_2 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_2
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_3 BLA0_3 BLA1_3 BLA2_3 BLA3_3 BLB0_3 BLB1_3 BLB2_3 BLB3_3 DFT DWL DWL
+  NBLA0_3 NBLA1_3 NBLA2_3 NBLA3_3 NBLB0_3 NBLB1_3 NBLB2_3 NBLB3_3 NSAE
+  NWRDATA_3 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_3 SAPRECH
+  RD_2 RD_3 TIELO VDDC_3 VDDCE_3 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_3
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_4 BLA0_4 BLA1_4 BLA2_4 BLA3_4 BLB0_4 BLB1_4 BLB2_4 BLB3_4 DFT DWL DWL
+  NBLA0_4 NBLA1_4 NBLA2_4 NBLA3_4 NBLB0_4 NBLB1_4 NBLB2_4 NBLB3_4 NSAE
+  NWRDATA_4 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_4 SAPRECH
+  RD_3 RD_4 TIELO VDDC_4 VDDCE_4 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_4
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_5 BLA0_5 BLA1_5 BLA2_5 BLA3_5 BLB0_5 BLB1_5 BLB2_5 BLB3_5 DFT DWL DWL
+  NBLA0_5 NBLA1_5 NBLA2_5 NBLA3_5 NBLB0_5 NBLB1_5 NBLB2_5 NBLB3_5 NSAE
+  NWRDATA_5 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_5 SAPRECH
+  RD_4 RD_5 TIELO VDDC_5 VDDCE_5 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_5
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_6 BLA0_6 BLA1_6 BLA2_6 BLA3_6 BLB0_6 BLB1_6 BLB2_6 BLB3_6 DFT DWL DWL
+  NBLA0_6 NBLA1_6 NBLA2_6 NBLA3_6 NBLB0_6 NBLB1_6 NBLB2_6 NBLB3_6 NSAE
+  NWRDATA_6 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_6 SAPRECH
+  RD_5 RD_6 TIELO VDDC_6 VDDCE_6 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_6
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_FARWD BLA0_7 BLA1_7 BLA2_7 BLA3_7 BLB0_7 BLB1_7 BLB2_7 BLB3_7 DFT DWL DWL
+  NBLA0_7 NBLA1_7 NBLA2_7 NBLA3_7 NBLB0_7 NBLB1_7 NBLB2_7 NBLB3_7 NSAE
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB SO SAPRECH RD_6
+  SO TIELO VDDC_7 VDDCE_7 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_7 YPCLK0B
+  YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
XCD_NEARWD BLA0_0 BLA1_0 BLA2_0 BLA3_0 BLB0_0 BLB1_0 BLB2_0 BLB3_0 DFT DWL DWL
+  NBLA0_0 NBLA1_0 NBLA2_0 NBLA3_0 NBLB0_0 NBLB1_0 NBLB2_0 NBLB3_0 NSAE
+  NWRDATA_0 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 SAPRECH SI
+  RD_0 TIELO VDDC_0 VDDCE_0 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_0 YPCLK0B
+  YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CDM4_BST
.ENDS RAMTP1024X16CD_COLXREG_LT
****
.SUBCKT RAMTP1024X16CD_COLX_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLA2_0 BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1
+  BLA3_2 BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5
+  BLB1_6 BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7
+  BLB3_0 BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2
+  NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3
+  NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6
+  NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2
+  RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4
+  WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0
+  YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16CD_COLX_LT: 1000 flat devices **
XCD_COLXREG_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0 BLA2_1 BLA2_2
+  BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2 BLA3_3 BLA3_4
+  BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB2_0
+  BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0 BLB3_1 BLB3_2
+  BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5
+  NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6
+  NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0
+  NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1
+  NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7 NSAE NWRDATA_0 NWRDATA_1
+  NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6 NWRDATA_7 NYPCLK0A
+  NYPCLK1A NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC
+  VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5 WRDATA_6 WRDATA_7
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CD_COLXREG_LT
.ENDS RAMTP1024X16CD_COLX_LT
****
.SUBCKT RAMTP1024X16FLBIOM4 D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS VSSE
+  WEN WENY
** RAMTP1024X16FLBIOM4: 4 flat devices **
D0_0.D_Diode_X_dio VPW TWEN NDIO11LL AREA=0.035P PJ=0.78U
D0_1.D_Diode_X_dio VPW WEN NDIO11LL AREA=0.035P PJ=0.78U
D0_2.D_Diode_X_dio VPW TD NDIO11LL AREA=0.035P PJ=0.78U
D0_3.D_Diode_X_dio VPW D NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMTP1024X16FLBIOM4
****
.SUBCKT RAMTP1024X16WRGLTNHD D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS WEN
+  WENY
** RAMTP1024X16WRGLTNHD: 4 flat devices **
XI0 D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS VSS WEN WENY
+  RAMTP1024X16FLBIOM4
.ENDS RAMTP1024X16WRGLTNHD
****
.SUBCKT RAMTP1024X16XR_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TIELO TWEN_0 TWEN_1
+  TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VNWP VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6
+  VSS_7 WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1
+  WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP1024X16XR_COLX_LT: 32 flat devices **
XI0 D_0 Q_0 TD_0 TIELO TWEN_0 VDDCE_0 VDDPE_0 VNWP VPW VSS_0 WEN_0 WENY_0
+  RAMTP1024X16WRGLTNHD
XI1 D_1 Q_1 TD_1 TIELO TWEN_1 VDDCE_1 VDDPE_1 VNWP VPW VSS_1 WEN_1 WENY_1
+  RAMTP1024X16WRGLTNHD
XI2 D_2 Q_2 TD_2 TIELO TWEN_2 VDDCE_2 VDDPE_2 VNWP VPW VSS_2 WEN_2 WENY_2
+  RAMTP1024X16WRGLTNHD
XI3 D_3 Q_3 TD_3 TIELO TWEN_3 VDDCE_3 VDDPE_3 VNWP VPW VSS_3 WEN_3 WENY_3
+  RAMTP1024X16WRGLTNHD
XI4 D_4 Q_4 TD_4 TIELO TWEN_4 VDDCE_4 VDDPE_4 VNWP VPW VSS_4 WEN_4 WENY_4
+  RAMTP1024X16WRGLTNHD
XI5 D_5 Q_5 TD_5 TIELO TWEN_5 VDDCE_5 VDDPE_5 VNWP VPW VSS_5 WEN_5 WENY_5
+  RAMTP1024X16WRGLTNHD
XI6 D_6 Q_6 TD_6 TIELO TWEN_6 VDDCE_6 VDDPE_6 VNWP VPW VSS_6 WEN_6 WENY_6
+  RAMTP1024X16WRGLTNHD
XI7 D_7 Q_7 TD_7 TIELO TWEN_7 VDDCE_7 VDDPE_7 VNWP VPW VSS_7 WEN_7 WENY_7
+  RAMTP1024X16WRGLTNHD
.ENDS RAMTP1024X16XR_COLX_LT
****
.SUBCKT RAMTP1024X16BOT_IO_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0
+  BLA2_1 BLA2_2 BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2
+  BLA3_3 BLA3_4 BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4
+  BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6
+  BLB1_7 BLB2_0 BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0
+  BLB3_1 BLB3_2 BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6
+  NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7
+  NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5 NBLA2_6 NBLA2_7 NBLA3_0
+  NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6 NBLA3_7 NBLB0_0 NBLB0_1
+  NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2
+  NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0 NBLB2_1 NBLB2_2 NBLB2_3
+  NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1 NBLB3_2 NBLB3_3 NBLB3_4
+  NBLB3_5 NBLB3_6 NBLB3_7 NSAE NYPCLK0A NYPCLK1A NYPCLK2A NYPCLK3A PRECHA
+  PRECHB Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SI TIELO_0 TIELO_1 VDDCE_0
+  VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC VPW_0 VPW_1
+  VSSE WCLK WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YPCLK0B YPCLK1B
+  YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
** RAMTP1024X16BOT_IO_LT: 1442 flat devices **
XCD_COLX_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA2_0 BLA2_1 BLA2_2
+  BLA2_3 BLA2_4 BLA2_5 BLA2_6 BLA2_7 BLA3_0 BLA3_1 BLA3_2 BLA3_3 BLA3_4
+  BLA3_5 BLA3_6 BLA3_7 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB2_0
+  BLB2_1 BLB2_2 BLB2_3 BLB2_4 BLB2_5 BLB2_6 BLB2_7 BLB3_0 BLB3_1 BLB3_2
+  BLB3_3 BLB3_4 BLB3_5 BLB3_6 BLB3_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLA2_0 NBLA2_1 NBLA2_2 NBLA2_3 NBLA2_4 NBLA2_5
+  NBLA2_6 NBLA2_7 NBLA3_0 NBLA3_1 NBLA3_2 NBLA3_3 NBLA3_4 NBLA3_5 NBLA3_6
+  NBLA3_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NBLB2_0
+  NBLB2_1 NBLB2_2 NBLB2_3 NBLB2_4 NBLB2_5 NBLB2_6 NBLB2_7 NBLB3_0 NBLB3_1
+  NBLB3_2 NBLB3_3 NBLB3_4 NBLB3_5 NBLB3_6 NBLB3_7 NSAE WRZERO_0 WRZERO_1
+  WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7 NYPCLK0A NYPCLK1A
+  NYPCLK2A NYPCLK3A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6 SAPRECH
+  SI RD_7 TIELO_1 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC
+  VPW_0 WRONE_0 WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7
+  YPCLK0B YPCLK1B YPCLK2B YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3
+  RAMTP1024X16CD_COLX_LT
XENDBOT_COL_LT DFT DWL DWL NSAE NYPCLK0A YPCLK0B NYPCLK1A YPCLK1B NYPCLK2A
+  YPCLK2B NYPCLK3A YPCLK3B YPCOLCLK0 YPCOLCLK1 YPCOLCLK2 YPCOLCLK3 PRECHA
+  PRECHB SAPRECH RD_7 TIELO_0 TIELO_1 VDDCE_8 VDDPE VDDPE VDDPE VNWC VDDPE
+  VPW_0 VPW_1 VSSE VPW_0 VPW_0 WCLK WEN_7 RAMTP1024X16ENDBOT_COL_LT
XRD_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6 RD_7 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDCE_0 VDDCE_1
+  VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VPW_1 VPW_1 VPW_1 VPW_1 VPW_1 VPW_1 VPW_1
+  VPW_1 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMTP1024X16RD_COLX_L
XWR_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  RD_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE
+  VPW_1 VPW_0 WCLK WEN_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WRONE_0
+  WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7 WRZERO_0 WRZERO_1
+  WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7 RAMTP1024X16WR_COLX_L
XR_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 TIELO_0 VPW_0 VPW_0 VPW_0
+  VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VPW_1 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VPW_0 VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 RAMTP1024X16XR_COLX_LT
.ENDS RAMTP1024X16BOT_IO_LT
****
.SUBCKT RAMTP1024X16CC2X2 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC
+  VDDCE VDDPE VNWC VPW VSS VSSE WLA0 WLA1 WLB0 WLB1
** RAMTP1024X16CC2X2: 32 flat devices **
X_M_cc2x2_wl0_bl0.I34.MXNpdl NCORED_00 CORED_00 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXNpdr CORED_00 NCORED_00 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXNpgl_0 NBLB0 WLB0 NCORED_00 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgl_1 NBLA0 WLA0 NCORED_00 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgr_0 BLB0 WLB0 CORED_00 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgr_1 BLA0 WLA0 CORED_00 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXPpul NCORED_00 CORED_00 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXPpur CORED_00 NCORED_00 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpdl NCORED_01 CORED_01 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpdr CORED_01 NCORED_01 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpgl_0 NBLB1 WLB0 NCORED_01 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgl_1 NBLA1 WLA0 NCORED_01 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgr_0 BLB1 WLB0 CORED_01 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgr_1 BLA1 WLA0 CORED_01 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXPpul NCORED_01 CORED_01 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXPpur CORED_01 NCORED_01 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpdl NCORED_10 CORED_10 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpdr CORED_10 NCORED_10 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpgl_0 NBLB0 WLB1 NCORED_10 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgl_1 NBLA0 WLA1 NCORED_10 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgr_0 BLB0 WLB1 CORED_10 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgr_1 BLA0 WLA1 CORED_10 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXPpul NCORED_10 CORED_10 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXPpur CORED_10 NCORED_10 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpdl NCORED_11 CORED_11 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpdr CORED_11 NCORED_11 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpgl_0 NBLB1 WLB1 NCORED_11 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgl_1 NBLA1 WLA1 NCORED_11 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgr_0 BLB1 WLB1 CORED_11 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgr_1 BLA1 WLA1 CORED_11 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXPpul NCORED_11 CORED_11 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXPpur CORED_11 NCORED_11 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
.ENDS RAMTP1024X16CC2X2
****
.SUBCKT RAMTP1024X16CCCAPX2 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC
+  VDDCE VDDPE VNWC VPW VSS VSSE
** RAMTP1024X16CCCAPX2: 24 flat devices **
X_MXN0 NET21 VPW NBLA0 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN1 VPW VPW NET044 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN11 NET041 NET023 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN12 VPW NET027 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN13 VPW NET055 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN14 NET057 NET059 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN2 VPW VPW NET046 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN23 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN24 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN25 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN3 NET25 VPW BLA0 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN34 VPW VPW NET42 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN35 VPW VPW NET46 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN4 NET33 VPW NBLA1 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN6 NET17 VPW BLA1 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN7 VSSE NET063 NET062 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN8 VSSE NET019 NET050 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXNpgl VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXP10 VNWC NET027 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP11 VNWC NET023 NET020 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP12 NET018 NET019 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP7 NET034 NET063 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP8 VNWC NET059 NET028 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP9 VNWC NET055 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMTP1024X16CCCAPX2
****
.SUBCKT RAMTP1024X16CCSTRAPX2 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC
+  VDDCE VDDPE VNWC VPW VSS VSSE
** RAMTP1024X16CCSTRAPX2: 16 flat devices **
X_MXN0 NET57 VPW NBLA0 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN12 NET033 NET035 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN13 NET041 NET043 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN23 BLA0 VPW NET30 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN24 NBLA1 VPW NET22 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN25 BLA1 VPW NET26 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN3 NET53 VPW BLA0 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN4 NET49 VPW NBLA1 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN6 NET61 VPW BLA1 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN7 VSSE NET047 NET046 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN8 VSSE NET019 NET038 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXNpgl NBLA0 VPW NET34 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXP10 VDDC NET035 NET020 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP12 NET018 NET019 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP7 NET026 NET047 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP9 VDDC NET043 NET028 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMTP1024X16CCSTRAPX2
****
.SUBCKT RAMTP1024X16CC_COL_MUX1 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1
+  VDDC VDDPE VPW VSS WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7
+  WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16
+  WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25
+  WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34
+  WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43
+  WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52
+  WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61
+  WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70
+  WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79
+  WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88
+  WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97
+  WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104 WLA0_105
+  WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112 WLA0_113
+  WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120 WLA0_121
+  WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2
+  WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12
+  WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21
+  WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30
+  WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39
+  WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48
+  WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57
+  WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66
+  WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75
+  WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84
+  WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93
+  WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102
+  WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110
+  WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118
+  WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126
+  WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8
+  WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17
+  WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26
+  WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35
+  WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44
+  WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53
+  WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62
+  WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71
+  WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80
+  WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89
+  WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98
+  WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104 WLB0_105 WLB0_106
+  WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112 WLB0_113 WLB0_114
+  WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120 WLB0_121 WLB0_122
+  WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40
+  WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49
+  WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58
+  WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67
+  WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76
+  WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85
+  WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94
+  WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103
+  WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111
+  WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119
+  WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16CC_COL_MUX1: 4160 flat devices **
XCC2X2_BOT BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC
+  VPW VSS VPW WLA0_0 WLA1_0 WLB0_0 WLB1_0 RAMTP1024X16CC2X2
XCC2X2_TOP BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC
+  VPW VSS VPW WLA0_127 WLA1_127 WLB0_127 WLB1_127 RAMTP1024X16CC2X2
XI0 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW RAMTP1024X16CCCAPX2
XI10 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_8 WLA1_8 WLB0_8 WLB1_8 RAMTP1024X16CC2X2
XI100 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_97 WLA1_97 WLB0_97 WLB1_97 RAMTP1024X16CC2X2
XI101 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_98 WLA1_98 WLB0_98 WLB1_98 RAMTP1024X16CC2X2
XI102 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_99 WLA1_99 WLB0_99 WLB1_99 RAMTP1024X16CC2X2
XI103 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_100 WLA1_100 WLB0_100 WLB1_100 RAMTP1024X16CC2X2
XI104 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_101 WLA1_101 WLB0_101 WLB1_101 RAMTP1024X16CC2X2
XI105 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_102 WLA1_102 WLB0_102 WLB1_102 RAMTP1024X16CC2X2
XI106 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_103 WLA1_103 WLB0_103 WLB1_103 RAMTP1024X16CC2X2
XI107 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_104 WLA1_104 WLB0_104 WLB1_104 RAMTP1024X16CC2X2
XI108 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_105 WLA1_105 WLB0_105 WLB1_105 RAMTP1024X16CC2X2
XI109 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_106 WLA1_106 WLB0_106 WLB1_106 RAMTP1024X16CC2X2
XI11 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_9 WLA1_9 WLB0_9 WLB1_9 RAMTP1024X16CC2X2
XI110 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_107 WLA1_107 WLB0_107 WLB1_107 RAMTP1024X16CC2X2
XI111 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_108 WLA1_108 WLB0_108 WLB1_108 RAMTP1024X16CC2X2
XI112 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_109 WLA1_109 WLB0_109 WLB1_109 RAMTP1024X16CC2X2
XI113 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_110 WLA1_110 WLB0_110 WLB1_110 RAMTP1024X16CC2X2
XI114 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_111 WLA1_111 WLB0_111 WLB1_111 RAMTP1024X16CC2X2
XI115 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_112 WLA1_112 WLB0_112 WLB1_112 RAMTP1024X16CC2X2
XI116 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_113 WLA1_113 WLB0_113 WLB1_113 RAMTP1024X16CC2X2
XI117 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_114 WLA1_114 WLB0_114 WLB1_114 RAMTP1024X16CC2X2
XI118 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_115 WLA1_115 WLB0_115 WLB1_115 RAMTP1024X16CC2X2
XI119 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_116 WLA1_116 WLB0_116 WLB1_116 RAMTP1024X16CC2X2
XI12 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_10 WLA1_10 WLB0_10 WLB1_10 RAMTP1024X16CC2X2
XI120 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_117 WLA1_117 WLB0_117 WLB1_117 RAMTP1024X16CC2X2
XI121 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_118 WLA1_118 WLB0_118 WLB1_118 RAMTP1024X16CC2X2
XI122 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_119 WLA1_119 WLB0_119 WLB1_119 RAMTP1024X16CC2X2
XI123 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_120 WLA1_120 WLB0_120 WLB1_120 RAMTP1024X16CC2X2
XI124 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_121 WLA1_121 WLB0_121 WLB1_121 RAMTP1024X16CC2X2
XI125 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_122 WLA1_122 WLB0_122 WLB1_122 RAMTP1024X16CC2X2
XI126 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_123 WLA1_123 WLB0_123 WLB1_123 RAMTP1024X16CC2X2
XI127 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_124 WLA1_124 WLB0_124 WLB1_124 RAMTP1024X16CC2X2
XI128 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_125 WLA1_125 WLB0_125 WLB1_125 RAMTP1024X16CC2X2
XI129 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_126 WLA1_126 WLB0_126 WLB1_126 RAMTP1024X16CC2X2
XI13 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_11 WLA1_11 WLB0_11 WLB1_11 RAMTP1024X16CC2X2
XI131 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW RAMTP1024X16CCCAPX2
XI14 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_12 WLA1_12 WLB0_12 WLB1_12 RAMTP1024X16CC2X2
XI15 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_13 WLA1_13 WLB0_13 WLB1_13 RAMTP1024X16CC2X2
XI16 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_14 WLA1_14 WLB0_14 WLB1_14 RAMTP1024X16CC2X2
XI17 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_15 WLA1_15 WLB0_15 WLB1_15 RAMTP1024X16CC2X2
XI18 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_16 WLA1_16 WLB0_16 WLB1_16 RAMTP1024X16CC2X2
XI19 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_17 WLA1_17 WLB0_17 WLB1_17 RAMTP1024X16CC2X2
XI20 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_18 WLA1_18 WLB0_18 WLB1_18 RAMTP1024X16CC2X2
XI21 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_19 WLA1_19 WLB0_19 WLB1_19 RAMTP1024X16CC2X2
XI22 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_20 WLA1_20 WLB0_20 WLB1_20 RAMTP1024X16CC2X2
XI23 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_21 WLA1_21 WLB0_21 WLB1_21 RAMTP1024X16CC2X2
XI24 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_22 WLA1_22 WLB0_22 WLB1_22 RAMTP1024X16CC2X2
XI25 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_23 WLA1_23 WLB0_23 WLB1_23 RAMTP1024X16CC2X2
XI26 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_24 WLA1_24 WLB0_24 WLB1_24 RAMTP1024X16CC2X2
XI27 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_25 WLA1_25 WLB0_25 WLB1_25 RAMTP1024X16CC2X2
XI28 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_26 WLA1_26 WLB0_26 WLB1_26 RAMTP1024X16CC2X2
XI29 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_27 WLA1_27 WLB0_27 WLB1_27 RAMTP1024X16CC2X2
XI3 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_1 WLA1_1 WLB0_1 WLB1_1 RAMTP1024X16CC2X2
XI30 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_28 WLA1_28 WLB0_28 WLB1_28 RAMTP1024X16CC2X2
XI31 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_29 WLA1_29 WLB0_29 WLB1_29 RAMTP1024X16CC2X2
XI32 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_30 WLA1_30 WLB0_30 WLB1_30 RAMTP1024X16CC2X2
XI33 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_31 WLA1_31 WLB0_31 WLB1_31 RAMTP1024X16CC2X2
XI34 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_32 WLA1_32 WLB0_32 WLB1_32 RAMTP1024X16CC2X2
XI35 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_33 WLA1_33 WLB0_33 WLB1_33 RAMTP1024X16CC2X2
XI36 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_34 WLA1_34 WLB0_34 WLB1_34 RAMTP1024X16CC2X2
XI37 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_35 WLA1_35 WLB0_35 WLB1_35 RAMTP1024X16CC2X2
XI38 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_36 WLA1_36 WLB0_36 WLB1_36 RAMTP1024X16CC2X2
XI39 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_37 WLA1_37 WLB0_37 WLB1_37 RAMTP1024X16CC2X2
XI4 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_2 WLA1_2 WLB0_2 WLB1_2 RAMTP1024X16CC2X2
XI40 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_38 WLA1_38 WLB0_38 WLB1_38 RAMTP1024X16CC2X2
XI41 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_39 WLA1_39 WLB0_39 WLB1_39 RAMTP1024X16CC2X2
XI42 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_40 WLA1_40 WLB0_40 WLB1_40 RAMTP1024X16CC2X2
XI43 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_41 WLA1_41 WLB0_41 WLB1_41 RAMTP1024X16CC2X2
XI44 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_42 WLA1_42 WLB0_42 WLB1_42 RAMTP1024X16CC2X2
XI45 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_43 WLA1_43 WLB0_43 WLB1_43 RAMTP1024X16CC2X2
XI46 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_44 WLA1_44 WLB0_44 WLB1_44 RAMTP1024X16CC2X2
XI47 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_45 WLA1_45 WLB0_45 WLB1_45 RAMTP1024X16CC2X2
XI48 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_46 WLA1_46 WLB0_46 WLB1_46 RAMTP1024X16CC2X2
XI49 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_47 WLA1_47 WLB0_47 WLB1_47 RAMTP1024X16CC2X2
XI5 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_3 WLA1_3 WLB0_3 WLB1_3 RAMTP1024X16CC2X2
XI50 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_48 WLA1_48 WLB0_48 WLB1_48 RAMTP1024X16CC2X2
XI51 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_49 WLA1_49 WLB0_49 WLB1_49 RAMTP1024X16CC2X2
XI52 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_50 WLA1_50 WLB0_50 WLB1_50 RAMTP1024X16CC2X2
XI53 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_51 WLA1_51 WLB0_51 WLB1_51 RAMTP1024X16CC2X2
XI54 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_52 WLA1_52 WLB0_52 WLB1_52 RAMTP1024X16CC2X2
XI55 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_53 WLA1_53 WLB0_53 WLB1_53 RAMTP1024X16CC2X2
XI56 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_54 WLA1_54 WLB0_54 WLB1_54 RAMTP1024X16CC2X2
XI57 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_55 WLA1_55 WLB0_55 WLB1_55 RAMTP1024X16CC2X2
XI58 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_56 WLA1_56 WLB0_56 WLB1_56 RAMTP1024X16CC2X2
XI59 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_57 WLA1_57 WLB0_57 WLB1_57 RAMTP1024X16CC2X2
XI6 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_4 WLA1_4 WLB0_4 WLB1_4 RAMTP1024X16CC2X2
XI60 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_58 WLA1_58 WLB0_58 WLB1_58 RAMTP1024X16CC2X2
XI61 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_59 WLA1_59 WLB0_59 WLB1_59 RAMTP1024X16CC2X2
XI62 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_60 WLA1_60 WLB0_60 WLB1_60 RAMTP1024X16CC2X2
XI63 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_61 WLA1_61 WLB0_61 WLB1_61 RAMTP1024X16CC2X2
XI64 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_62 WLA1_62 WLB0_62 WLB1_62 RAMTP1024X16CC2X2
XI65 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_63 WLA1_63 WLB0_63 WLB1_63 RAMTP1024X16CC2X2
XI66 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW RAMTP1024X16CCSTRAPX2
XI67 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_64 WLA1_64 WLB0_64 WLB1_64 RAMTP1024X16CC2X2
XI68 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_65 WLA1_65 WLB0_65 WLB1_65 RAMTP1024X16CC2X2
XI69 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_66 WLA1_66 WLB0_66 WLB1_66 RAMTP1024X16CC2X2
XI7 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_5 WLA1_5 WLB0_5 WLB1_5 RAMTP1024X16CC2X2
XI70 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_67 WLA1_67 WLB0_67 WLB1_67 RAMTP1024X16CC2X2
XI71 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_68 WLA1_68 WLB0_68 WLB1_68 RAMTP1024X16CC2X2
XI72 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_69 WLA1_69 WLB0_69 WLB1_69 RAMTP1024X16CC2X2
XI73 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_70 WLA1_70 WLB0_70 WLB1_70 RAMTP1024X16CC2X2
XI74 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_71 WLA1_71 WLB0_71 WLB1_71 RAMTP1024X16CC2X2
XI75 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_72 WLA1_72 WLB0_72 WLB1_72 RAMTP1024X16CC2X2
XI76 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_73 WLA1_73 WLB0_73 WLB1_73 RAMTP1024X16CC2X2
XI77 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_74 WLA1_74 WLB0_74 WLB1_74 RAMTP1024X16CC2X2
XI78 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_75 WLA1_75 WLB0_75 WLB1_75 RAMTP1024X16CC2X2
XI79 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_76 WLA1_76 WLB0_76 WLB1_76 RAMTP1024X16CC2X2
XI8 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_6 WLA1_6 WLB0_6 WLB1_6 RAMTP1024X16CC2X2
XI80 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_77 WLA1_77 WLB0_77 WLB1_77 RAMTP1024X16CC2X2
XI81 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_78 WLA1_78 WLB0_78 WLB1_78 RAMTP1024X16CC2X2
XI82 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_79 WLA1_79 WLB0_79 WLB1_79 RAMTP1024X16CC2X2
XI83 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_80 WLA1_80 WLB0_80 WLB1_80 RAMTP1024X16CC2X2
XI84 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_81 WLA1_81 WLB0_81 WLB1_81 RAMTP1024X16CC2X2
XI85 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_82 WLA1_82 WLB0_82 WLB1_82 RAMTP1024X16CC2X2
XI86 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_83 WLA1_83 WLB0_83 WLB1_83 RAMTP1024X16CC2X2
XI87 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_84 WLA1_84 WLB0_84 WLB1_84 RAMTP1024X16CC2X2
XI88 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_85 WLA1_85 WLB0_85 WLB1_85 RAMTP1024X16CC2X2
XI89 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_86 WLA1_86 WLB0_86 WLB1_86 RAMTP1024X16CC2X2
XI9 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_7 WLA1_7 WLB0_7 WLB1_7 RAMTP1024X16CC2X2
XI90 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_87 WLA1_87 WLB0_87 WLB1_87 RAMTP1024X16CC2X2
XI91 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_88 WLA1_88 WLB0_88 WLB1_88 RAMTP1024X16CC2X2
XI92 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_89 WLA1_89 WLB0_89 WLB1_89 RAMTP1024X16CC2X2
XI93 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_90 WLA1_90 WLB0_90 WLB1_90 RAMTP1024X16CC2X2
XI94 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_91 WLA1_91 WLB0_91 WLB1_91 RAMTP1024X16CC2X2
XI95 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_92 WLA1_92 WLB0_92 WLB1_92 RAMTP1024X16CC2X2
XI96 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_93 WLA1_93 WLB0_93 WLB1_93 RAMTP1024X16CC2X2
XI97 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_94 WLA1_94 WLB0_94 WLB1_94 RAMTP1024X16CC2X2
XI98 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_95 WLA1_95 WLB0_95 WLB1_95 RAMTP1024X16CC2X2
XI99 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_96 WLA1_96 WLB0_96 WLB1_96 RAMTP1024X16CC2X2
.ENDS RAMTP1024X16CC_COL_MUX1
****
.SUBCKT RAMTP1024X16CORE_COLX_L BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA0_8 BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15
+  BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9
+  BLA1_10 BLA1_11 BLA1_12 BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13
+  BLB0_14 BLB0_15 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7
+  BLB1_8 BLB1_9 BLB1_10 BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9
+  NBLA0_10 NBLA0_11 NBLA0_12 NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10
+  NBLA1_11 NBLA1_12 NBLA1_13 NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2
+  NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11
+  NBLB0_12 NBLB0_13 NBLB0_14 NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4
+  NBLB1_5 NBLB1_6 NBLB1_7 NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13
+  NBLB1_14 NBLB1_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 VSS_8
+  VSS_9 VSS_10 VSS_11 VSS_12 VSS_13 VSS_14 VSS_15 WLA0_0 WLA0_1 WLA0_2 WLA0_3
+  WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13
+  WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22
+  WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31
+  WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40
+  WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49
+  WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58
+  WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67
+  WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76
+  WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85
+  WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94
+  WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103
+  WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111
+  WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119
+  WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127
+  WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36
+  WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45
+  WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54
+  WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63
+  WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72
+  WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81
+  WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90
+  WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99
+  WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107
+  WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115
+  WLA1_116 WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123
+  WLA1_124 WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4
+  WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14
+  WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23
+  WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32
+  WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41
+  WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50
+  WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59
+  WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68
+  WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77
+  WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86
+  WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95
+  WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103
+  WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111
+  WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119
+  WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127
+  WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36
+  WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45
+  WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54
+  WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63
+  WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72
+  WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81
+  WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90
+  WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99
+  WLB1_100 WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107
+  WLB1_108 WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115
+  WLB1_116 WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123
+  WLB1_124 WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16CORE_COLX_L: 66560 flat devices **
XCC2X2_COL_FARWD BLA0_14 BLA1_14 BLB0_14 BLB1_14 NBLA0_14 NBLA1_14 NBLB0_14
+  NBLB1_14 VDDC VDDPE_14 VPW VSS_14 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_FARWD_23 BLA0_15 BLA1_15 BLB0_15 BLB1_15 NBLA0_15 NBLA1_15 NBLB0_15
+  NBLB1_15 VDDC VDDPE_15 VPW VSS_15 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 NBLA0_0 NBLA1_0 NBLB0_0 NBLB1_0
+  VDDC VDDPE_0 VPW VSS_0 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XCC2X2_COL_NEARWD_23 BLA0_1 BLA1_1 BLB0_1 BLB1_1 NBLA0_1 NBLA1_1 NBLB0_1
+  NBLB1_1 VDDC VDDPE_1 VPW VSS_1 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_10 BLA0_10 BLA1_10 BLB0_10 BLB1_10 NBLA0_10 NBLA1_10 NBLB0_10
+  NBLB1_10 VDDC VDDPE_10 VPW VSS_10 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_11 BLA0_11 BLA1_11 BLB0_11 BLB1_11 NBLA0_11 NBLA1_11 NBLB0_11
+  NBLB1_11 VDDC VDDPE_11 VPW VSS_11 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_12 BLA0_12 BLA1_12 BLB0_12 BLB1_12 NBLA0_12 NBLA1_12 NBLB0_12
+  NBLB1_12 VDDC VDDPE_12 VPW VSS_12 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_13 BLA0_13 BLA1_13 BLB0_13 BLB1_13 NBLA0_13 NBLA1_13 NBLB0_13
+  NBLB1_13 VDDC VDDPE_13 VPW VSS_13 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5
+  WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  VDDC VDDPE_2 VPW VSS_2 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  VDDC VDDPE_3 VPW VSS_3 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  VDDC VDDPE_4 VPW VSS_4 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  VDDC VDDPE_5 VPW VSS_5 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  VDDC VDDPE_6 VPW VSS_6 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_7 BLA0_7 BLA1_7 BLB0_7 BLB1_7 NBLA0_7 NBLA1_7 NBLB0_7 NBLB1_7
+  VDDC VDDPE_7 VPW VSS_7 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_8 BLA0_8 BLA1_8 BLB0_8 BLB1_8 NBLA0_8 NBLA1_8 NBLB0_8 NBLB1_8
+  VDDC VDDPE_8 VPW VSS_8 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
XLCC_COL_MUX1_9 BLA0_9 BLA1_9 BLB0_9 BLB1_9 NBLA0_9 NBLA1_9 NBLB0_9 NBLB1_9
+  VDDC VDDPE_9 VPW VSS_9 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CC_COL_MUX1
.ENDS RAMTP1024X16CORE_COLX_L
****
.SUBCKT RAMTP1024X16CORE_COLXL BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA0_8 BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15
+  BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9
+  BLA1_10 BLA1_11 BLA1_12 BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3
+  BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13
+  BLB0_14 BLB0_15 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7
+  BLB1_8 BLB1_9 BLB1_10 BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9
+  NBLA0_10 NBLA0_11 NBLA0_12 NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10
+  NBLA1_11 NBLA1_12 NBLA1_13 NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2
+  NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11
+  NBLB0_12 NBLB0_13 NBLB0_14 NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4
+  NBLB1_5 NBLB1_6 NBLB1_7 NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13
+  NBLB1_14 NBLB1_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA0_32 WLA0_33
+  WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38 WLA0_39 WLA0_40 WLA0_41 WLA0_42
+  WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47 WLA0_48 WLA0_49 WLA0_50 WLA0_51
+  WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56 WLA0_57 WLA0_58 WLA0_59 WLA0_60
+  WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65 WLA0_66 WLA0_67 WLA0_68 WLA0_69
+  WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74 WLA0_75 WLA0_76 WLA0_77 WLA0_78
+  WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83 WLA0_84 WLA0_85 WLA0_86 WLA0_87
+  WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92 WLA0_93 WLA0_94 WLA0_95 WLA0_96
+  WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101 WLA0_102 WLA0_103 WLA0_104
+  WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109 WLA0_110 WLA0_111 WLA0_112
+  WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117 WLA0_118 WLA0_119 WLA0_120
+  WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125 WLA0_126 WLA0_127 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34 WLA1_35 WLA1_36 WLA1_37
+  WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43 WLA1_44 WLA1_45 WLA1_46
+  WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52 WLA1_53 WLA1_54 WLA1_55
+  WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61 WLA1_62 WLA1_63 WLA1_64
+  WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70 WLA1_71 WLA1_72 WLA1_73
+  WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79 WLA1_80 WLA1_81 WLA1_82
+  WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88 WLA1_89 WLA1_90 WLA1_91
+  WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97 WLA1_98 WLA1_99 WLA1_100
+  WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105 WLA1_106 WLA1_107 WLA1_108
+  WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113 WLA1_114 WLA1_115 WLA1_116
+  WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121 WLA1_122 WLA1_123 WLA1_124
+  WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB0_32 WLB0_33
+  WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39 WLB0_40 WLB0_41 WLB0_42
+  WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48 WLB0_49 WLB0_50 WLB0_51
+  WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57 WLB0_58 WLB0_59 WLB0_60
+  WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66 WLB0_67 WLB0_68 WLB0_69
+  WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75 WLB0_76 WLB0_77 WLB0_78
+  WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84 WLB0_85 WLB0_86 WLB0_87
+  WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93 WLB0_94 WLB0_95 WLB0_96
+  WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102 WLB0_103 WLB0_104
+  WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110 WLB0_111 WLB0_112
+  WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118 WLB0_119 WLB0_120
+  WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126 WLB0_127 WLB1_0
+  WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10
+  WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35 WLB1_36 WLB1_37
+  WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44 WLB1_45 WLB1_46
+  WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53 WLB1_54 WLB1_55
+  WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62 WLB1_63 WLB1_64
+  WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71 WLB1_72 WLB1_73
+  WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80 WLB1_81 WLB1_82
+  WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89 WLB1_90 WLB1_91
+  WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98 WLB1_99 WLB1_100
+  WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106 WLB1_107 WLB1_108
+  WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114 WLB1_115 WLB1_116
+  WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122 WLB1_123 WLB1_124
+  WLB1_125 WLB1_126 WLB1_127
** RAMTP1024X16CORE_COLXL: 66560 flat devices **
XCORE_COLXS_L BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA0_8
+  BLA0_9 BLA0_10 BLA0_11 BLA0_12 BLA0_13 BLA0_14 BLA0_15 BLA1_0 BLA1_1 BLA1_2
+  BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLA1_8 BLA1_9 BLA1_10 BLA1_11 BLA1_12
+  BLA1_13 BLA1_14 BLA1_15 BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6
+  BLB0_7 BLB0_8 BLB0_9 BLB0_10 BLB0_11 BLB0_12 BLB0_13 BLB0_14 BLB0_15 BLB1_0
+  BLB1_1 BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 BLB1_8 BLB1_9 BLB1_10
+  BLB1_11 BLB1_12 BLB1_13 BLB1_14 BLB1_15 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA0_8 NBLA0_9 NBLA0_10 NBLA0_11 NBLA0_12
+  NBLA0_13 NBLA0_14 NBLA0_15 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLA1_8 NBLA1_9 NBLA1_10 NBLA1_11 NBLA1_12 NBLA1_13
+  NBLA1_14 NBLA1_15 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB0_8 NBLB0_9 NBLB0_10 NBLB0_11 NBLB0_12 NBLB0_13 NBLB0_14
+  NBLB0_15 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NBLB1_8 NBLB1_9 NBLB1_10 NBLB1_11 NBLB1_12 NBLB1_13 NBLB1_14 NBLB1_15 VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW WLA0_0 WLA0_1
+  WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11
+  WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20
+  WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29
+  WLA0_30 WLA0_31 WLA0_32 WLA0_33 WLA0_34 WLA0_35 WLA0_36 WLA0_37 WLA0_38
+  WLA0_39 WLA0_40 WLA0_41 WLA0_42 WLA0_43 WLA0_44 WLA0_45 WLA0_46 WLA0_47
+  WLA0_48 WLA0_49 WLA0_50 WLA0_51 WLA0_52 WLA0_53 WLA0_54 WLA0_55 WLA0_56
+  WLA0_57 WLA0_58 WLA0_59 WLA0_60 WLA0_61 WLA0_62 WLA0_63 WLA0_64 WLA0_65
+  WLA0_66 WLA0_67 WLA0_68 WLA0_69 WLA0_70 WLA0_71 WLA0_72 WLA0_73 WLA0_74
+  WLA0_75 WLA0_76 WLA0_77 WLA0_78 WLA0_79 WLA0_80 WLA0_81 WLA0_82 WLA0_83
+  WLA0_84 WLA0_85 WLA0_86 WLA0_87 WLA0_88 WLA0_89 WLA0_90 WLA0_91 WLA0_92
+  WLA0_93 WLA0_94 WLA0_95 WLA0_96 WLA0_97 WLA0_98 WLA0_99 WLA0_100 WLA0_101
+  WLA0_102 WLA0_103 WLA0_104 WLA0_105 WLA0_106 WLA0_107 WLA0_108 WLA0_109
+  WLA0_110 WLA0_111 WLA0_112 WLA0_113 WLA0_114 WLA0_115 WLA0_116 WLA0_117
+  WLA0_118 WLA0_119 WLA0_120 WLA0_121 WLA0_122 WLA0_123 WLA0_124 WLA0_125
+  WLA0_126 WLA0_127 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7
+  WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16
+  WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25
+  WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA1_32 WLA1_33 WLA1_34
+  WLA1_35 WLA1_36 WLA1_37 WLA1_38 WLA1_39 WLA1_40 WLA1_41 WLA1_42 WLA1_43
+  WLA1_44 WLA1_45 WLA1_46 WLA1_47 WLA1_48 WLA1_49 WLA1_50 WLA1_51 WLA1_52
+  WLA1_53 WLA1_54 WLA1_55 WLA1_56 WLA1_57 WLA1_58 WLA1_59 WLA1_60 WLA1_61
+  WLA1_62 WLA1_63 WLA1_64 WLA1_65 WLA1_66 WLA1_67 WLA1_68 WLA1_69 WLA1_70
+  WLA1_71 WLA1_72 WLA1_73 WLA1_74 WLA1_75 WLA1_76 WLA1_77 WLA1_78 WLA1_79
+  WLA1_80 WLA1_81 WLA1_82 WLA1_83 WLA1_84 WLA1_85 WLA1_86 WLA1_87 WLA1_88
+  WLA1_89 WLA1_90 WLA1_91 WLA1_92 WLA1_93 WLA1_94 WLA1_95 WLA1_96 WLA1_97
+  WLA1_98 WLA1_99 WLA1_100 WLA1_101 WLA1_102 WLA1_103 WLA1_104 WLA1_105
+  WLA1_106 WLA1_107 WLA1_108 WLA1_109 WLA1_110 WLA1_111 WLA1_112 WLA1_113
+  WLA1_114 WLA1_115 WLA1_116 WLA1_117 WLA1_118 WLA1_119 WLA1_120 WLA1_121
+  WLA1_122 WLA1_123 WLA1_124 WLA1_125 WLA1_126 WLA1_127 WLB0_0 WLB0_1 WLB0_2
+  WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12
+  WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21
+  WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30
+  WLB0_31 WLB0_32 WLB0_33 WLB0_34 WLB0_35 WLB0_36 WLB0_37 WLB0_38 WLB0_39
+  WLB0_40 WLB0_41 WLB0_42 WLB0_43 WLB0_44 WLB0_45 WLB0_46 WLB0_47 WLB0_48
+  WLB0_49 WLB0_50 WLB0_51 WLB0_52 WLB0_53 WLB0_54 WLB0_55 WLB0_56 WLB0_57
+  WLB0_58 WLB0_59 WLB0_60 WLB0_61 WLB0_62 WLB0_63 WLB0_64 WLB0_65 WLB0_66
+  WLB0_67 WLB0_68 WLB0_69 WLB0_70 WLB0_71 WLB0_72 WLB0_73 WLB0_74 WLB0_75
+  WLB0_76 WLB0_77 WLB0_78 WLB0_79 WLB0_80 WLB0_81 WLB0_82 WLB0_83 WLB0_84
+  WLB0_85 WLB0_86 WLB0_87 WLB0_88 WLB0_89 WLB0_90 WLB0_91 WLB0_92 WLB0_93
+  WLB0_94 WLB0_95 WLB0_96 WLB0_97 WLB0_98 WLB0_99 WLB0_100 WLB0_101 WLB0_102
+  WLB0_103 WLB0_104 WLB0_105 WLB0_106 WLB0_107 WLB0_108 WLB0_109 WLB0_110
+  WLB0_111 WLB0_112 WLB0_113 WLB0_114 WLB0_115 WLB0_116 WLB0_117 WLB0_118
+  WLB0_119 WLB0_120 WLB0_121 WLB0_122 WLB0_123 WLB0_124 WLB0_125 WLB0_126
+  WLB0_127 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8
+  WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17
+  WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26
+  WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 WLB1_32 WLB1_33 WLB1_34 WLB1_35
+  WLB1_36 WLB1_37 WLB1_38 WLB1_39 WLB1_40 WLB1_41 WLB1_42 WLB1_43 WLB1_44
+  WLB1_45 WLB1_46 WLB1_47 WLB1_48 WLB1_49 WLB1_50 WLB1_51 WLB1_52 WLB1_53
+  WLB1_54 WLB1_55 WLB1_56 WLB1_57 WLB1_58 WLB1_59 WLB1_60 WLB1_61 WLB1_62
+  WLB1_63 WLB1_64 WLB1_65 WLB1_66 WLB1_67 WLB1_68 WLB1_69 WLB1_70 WLB1_71
+  WLB1_72 WLB1_73 WLB1_74 WLB1_75 WLB1_76 WLB1_77 WLB1_78 WLB1_79 WLB1_80
+  WLB1_81 WLB1_82 WLB1_83 WLB1_84 WLB1_85 WLB1_86 WLB1_87 WLB1_88 WLB1_89
+  WLB1_90 WLB1_91 WLB1_92 WLB1_93 WLB1_94 WLB1_95 WLB1_96 WLB1_97 WLB1_98
+  WLB1_99 WLB1_100 WLB1_101 WLB1_102 WLB1_103 WLB1_104 WLB1_105 WLB1_106
+  WLB1_107 WLB1_108 WLB1_109 WLB1_110 WLB1_111 WLB1_112 WLB1_113 WLB1_114
+  WLB1_115 WLB1_116 WLB1_117 WLB1_118 WLB1_119 WLB1_120 WLB1_121 WLB1_122
+  WLB1_123 WLB1_124 WLB1_125 WLB1_126 WLB1_127 RAMTP1024X16CORE_COLX_L
.ENDS RAMTP1024X16CORE_COLXL
****
.SUBCKT RAMTP1024X16FPCTRL_BASIC CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB
+  COLLDISN DFTRAMBYPA DFTRAMBYPB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 LAA0
+  LAA1 LAB0 LAB1 PGEN RAA0 RAA1 RAA2 RAA3 RAA4 RAA5 RAB0 RAB1 RAB2 RAB3 RAB4
+  RAB5 RDT RET1N RET2N SIA0 SIA1 TIELOFPA TIELOFPB VDDCE VDDPE VNWC VNWP VPW
+  VSS VSSE
** RAMTP1024X16FPCTRL_BASIC: 35 flat devices **
D0.D_Diode_X_dio VPW CENA NDIO11LL AREA=0.035P PJ=0.78U
D1_0.D_Diode_X_dio VPW CAA0 NDIO11LL AREA=0.035P PJ=0.78U
D1_1.D_Diode_X_dio VPW CAA1 NDIO11LL AREA=0.035P PJ=0.78U
D1_2.D_Diode_X_dio VPW LAA0 NDIO11LL AREA=0.035P PJ=0.78U
D1_3.D_Diode_X_dio VPW LAA1 NDIO11LL AREA=0.035P PJ=0.78U
D1_4.D_Diode_X_dio VPW RAA0 NDIO11LL AREA=0.035P PJ=0.78U
D1_5.D_Diode_X_dio VPW RAA1 NDIO11LL AREA=0.035P PJ=0.78U
D1_6.D_Diode_X_dio VPW RAA2 NDIO11LL AREA=0.035P PJ=0.78U
D1_7.D_Diode_X_dio VPW RAA3 NDIO11LL AREA=0.035P PJ=0.78U
D1_8.D_Diode_X_dio VPW RAA4 NDIO11LL AREA=0.035P PJ=0.78U
D1_9.D_Diode_X_dio VPW RAA5 NDIO11LL AREA=0.035P PJ=0.78U
D3_0.D_Diode_X_dio VPW CLKA NDIO11LL AREA=0.035P PJ=0.78U
D3_1.D_Diode_X_dio VPW RDT NDIO11LL AREA=0.035P PJ=0.78U
D3_2.D_Diode_X_dio VPW EMAA0 NDIO11LL AREA=0.035P PJ=0.78U
D3_3.D_Diode_X_dio VPW EMAA1 NDIO11LL AREA=0.035P PJ=0.78U
D3_4.D_Diode_X_dio VPW EMAA2 NDIO11LL AREA=0.035P PJ=0.78U
D4_0.D_Diode_X_dio VPW CAB0 NDIO11LL AREA=0.035P PJ=0.78U
D4_1.D_Diode_X_dio VPW CAB1 NDIO11LL AREA=0.035P PJ=0.78U
D4_2.D_Diode_X_dio VPW LAB0 NDIO11LL AREA=0.035P PJ=0.78U
D4_3.D_Diode_X_dio VPW LAB1 NDIO11LL AREA=0.035P PJ=0.78U
D4_4.D_Diode_X_dio VPW RAB0 NDIO11LL AREA=0.035P PJ=0.78U
D4_5.D_Diode_X_dio VPW RAB1 NDIO11LL AREA=0.035P PJ=0.78U
D4_6.D_Diode_X_dio VPW RAB2 NDIO11LL AREA=0.035P PJ=0.78U
D4_7.D_Diode_X_dio VPW RAB3 NDIO11LL AREA=0.035P PJ=0.78U
D4_8.D_Diode_X_dio VPW RAB4 NDIO11LL AREA=0.035P PJ=0.78U
D4_9.D_Diode_X_dio VPW RAB5 NDIO11LL AREA=0.035P PJ=0.78U
D5_0.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
D5_1.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
D5_2.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
D6.D_Diode_X_dio VPW CENB NDIO11LL AREA=0.035P PJ=0.78U
D8_0.D_Diode_X_dio VPW CLKB NDIO11LL AREA=0.035P PJ=0.78U
D8_1.D_Diode_X_dio VPW COLLDISN NDIO11LL AREA=0.035P PJ=0.78U
D8_2.D_Diode_X_dio VPW EMAB0 NDIO11LL AREA=0.035P PJ=0.78U
D8_3.D_Diode_X_dio VPW EMAB1 NDIO11LL AREA=0.035P PJ=0.78U
D8_4.D_Diode_X_dio VPW EMAB2 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMTP1024X16FPCTRL_BASIC
****
.SUBCKT RAMTP1024X16CKM4_BASIC CAA0 CAA1 CAB0 CAB1 CENA CENB CLKA CLKB
+  COLLDISN DBLA DBLB DFTRAMBYPA DFTRAMBYPB DFTRETA DFTRETB DWLA DWLATURN
+  DWLAV DWLB DWLBTURN DWLBV EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA GTPB
+  ISAE_DUM0 ISAE_DUM1 LAA0 LAA1 LAA_P2[0] LAA_P2[1] LAB0 LAB1 LAB_P2[0]
+  LAB_P2[1] NACTC NRETNVT NSAE NYPACLK[0] NYPACLK[1] NYPACLK[2] NYPACLK[3]
+  PRECHA_L PRECHA_R PRECHB_L PRECHB_R RAA0 RAA1 RAA2 RAA3 RAA4 RAA5 RAA_P2[0]
+  RAA_P2[1] RAA_P2[2] RAA_P2[3] RAA_P2[4] RAA_P2[5] RAB0 RAB1 RAB2 RAB3 RAB4
+  RAB5 RAB_P2[0] RAB_P2[1] RAB_P2[2] RAB_P2[3] RAB_P2[4] RAB_P2[5] RDT RET1N
+  SAEDIN SAEDO0 SAEDO1 SAE_DUMMY SAPRECH SIA0 SIA1 TIEHIA TIEHIB TIELOCDA
+  TIELOCDB TIELODBLA TIELODBLB TIELOFPA TIELOFPB VDDCE VDDC_WLA VDDC_WLB
+  VDDPE VDDP_DWLA VDDP_DWLB VNWC VNWP VPW VSS VSSE WCLK WEN YPBCLK[0]
+  YPBCLK[1] YPBCLK[2] YPBCLK[3] YPCOL[0] YPCOL[1] YPCOL[2] YPCOL[3]
** RAMTP1024X16CKM4_BASIC: 1013 flat devices **
X_MI38.MXNA1 MOD_COLDISN MOD_RDT_P2 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI38.MXNA2 MOD_COLDISN NET141 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI38.MXPA1 MOD_COLDISN MOD_RDT_P2 I38.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_MI38.MXPA2 I38.P1 NET141 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI39.MXNA1 NET141 COLLDISN VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI39.MXPA1 NET141 COLLDISN VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_0.I47.MXNA1 _ADDLATA._CADD_LAT_0.ND CAA0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0.I47.MXPA1 _ADDLATA._CADD_LAT_0.ND CAA0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_0.I48.MXNOE _ADDLATA.NCA_P2[0] NCLKA
+  _ADDLATA._CADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0.I48.MXPOEN _ADDLATA.NCA_P2[0] BCLKA
+  _ADDLATA._CADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._cadd_lat_0.I50.MXNA1 CAA_P2[0] _ADDLATA.NCA_P2[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._cadd_lat_0.I50.MXPA1 CAA_P2[0] _ADDLATA.NCA_P2[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._cadd_lat_0.I55.MXNA1 _ADDLATA._CADD_LAT_0.I55.N1 CAA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0.I55.MXNOE _ADDLATA.NCA_P2[0] BCLKA
+  _ADDLATA._CADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0.I55.MXPA1 _ADDLATA._CADD_LAT_0.I55.P1 CAA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0.I55.MXPOEN _ADDLATA.NCA_P2[0] NCLKA
+  _ADDLATA._CADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1.I47.MXNA1 _ADDLATA._CADD_LAT_1.ND CAA1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1.I47.MXPA1 _ADDLATA._CADD_LAT_1.ND CAA1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_1.I48.MXNOE _ADDLATA.NCA_P2[1] NCLKA
+  _ADDLATA._CADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1.I48.MXPOEN _ADDLATA.NCA_P2[1] BCLKA
+  _ADDLATA._CADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._cadd_lat_1.I50.MXNA1 CAA_P2[1] _ADDLATA.NCA_P2[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._cadd_lat_1.I50.MXPA1 CAA_P2[1] _ADDLATA.NCA_P2[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._cadd_lat_1.I55.MXNA1 _ADDLATA._CADD_LAT_1.I55.N1 CAA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1.I55.MXNOE _ADDLATA.NCA_P2[1] BCLKA
+  _ADDLATA._CADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1.I55.MXPA1 _ADDLATA._CADD_LAT_1.I55.P1 CAA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1.I55.MXPOEN _ADDLATA.NCA_P2[1] NCLKA
+  _ADDLATA._CADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0.I47.MXNA1 _ADDLATA._LADD_LAT_0.ND LAA0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0.I47.MXPA1 _ADDLATA._LADD_LAT_0.ND LAA0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_0.I48.MXNOE _ADDLATA.NET52[1] NCLKA
+  _ADDLATA._LADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0.I48.MXPOEN _ADDLATA.NET52[1] BCLKA
+  _ADDLATA._LADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._ladd_lat_0.I50.MXNA1 LAA_P2[0] _ADDLATA.NET52[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._ladd_lat_0.I50.MXPA1 LAA_P2[0] _ADDLATA.NET52[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._ladd_lat_0.I55.MXNA1 _ADDLATA._LADD_LAT_0.I55.N1 LAA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0.I55.MXNOE _ADDLATA.NET52[1] BCLKA
+  _ADDLATA._LADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0.I55.MXPA1 _ADDLATA._LADD_LAT_0.I55.P1 LAA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0.I55.MXPOEN _ADDLATA.NET52[1] NCLKA
+  _ADDLATA._LADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1.I47.MXNA1 _ADDLATA._LADD_LAT_1.ND LAA1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1.I47.MXPA1 _ADDLATA._LADD_LAT_1.ND LAA1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_1.I48.MXNOE _ADDLATA.NET52[0] NCLKA
+  _ADDLATA._LADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1.I48.MXPOEN _ADDLATA.NET52[0] BCLKA
+  _ADDLATA._LADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._ladd_lat_1.I50.MXNA1 LAA_P2[1] _ADDLATA.NET52[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._ladd_lat_1.I50.MXPA1 LAA_P2[1] _ADDLATA.NET52[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._ladd_lat_1.I55.MXNA1 _ADDLATA._LADD_LAT_1.I55.N1 LAA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1.I55.MXNOE _ADDLATA.NET52[0] BCLKA
+  _ADDLATA._LADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1.I55.MXPA1 _ADDLATA._LADD_LAT_1.I55.P1 LAA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1.I55.MXPOEN _ADDLATA.NET52[0] NCLKA
+  _ADDLATA._LADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0.I47.MXNA1 _ADDLATA._RADD_LAT_0.ND RAA0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0.I47.MXPA1 _ADDLATA._RADD_LAT_0.ND RAA0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_0.I48.MXNOE _ADDLATA.NET49[2] NCLKA
+  _ADDLATA._RADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0.I48.MXPOEN _ADDLATA.NET49[2] BCLKA
+  _ADDLATA._RADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_0.I50.MXNA1 RAA_P2[0] _ADDLATA.NET49[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_0.I50.MXPA1 RAA_P2[0] _ADDLATA.NET49[2] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_0.I55.MXNA1 _ADDLATA._RADD_LAT_0.I55.N1 RAA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0.I55.MXNOE _ADDLATA.NET49[2] BCLKA
+  _ADDLATA._RADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0.I55.MXPA1 _ADDLATA._RADD_LAT_0.I55.P1 RAA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0.I55.MXPOEN _ADDLATA.NET49[2] NCLKA
+  _ADDLATA._RADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1.I47.MXNA1 _ADDLATA._RADD_LAT_1.ND RAA1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1.I47.MXPA1 _ADDLATA._RADD_LAT_1.ND RAA1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_1.I48.MXNOE _ADDLATA.NET49[1] NCLKA
+  _ADDLATA._RADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1.I48.MXPOEN _ADDLATA.NET49[1] BCLKA
+  _ADDLATA._RADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_1.I50.MXNA1 RAA_P2[1] _ADDLATA.NET49[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_1.I50.MXPA1 RAA_P2[1] _ADDLATA.NET49[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_1.I55.MXNA1 _ADDLATA._RADD_LAT_1.I55.N1 RAA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1.I55.MXNOE _ADDLATA.NET49[1] BCLKA
+  _ADDLATA._RADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1.I55.MXPA1 _ADDLATA._RADD_LAT_1.I55.P1 RAA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1.I55.MXPOEN _ADDLATA.NET49[1] NCLKA
+  _ADDLATA._RADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2.I47.MXNA1 _ADDLATA._RADD_LAT_2.ND RAA2 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2.I47.MXPA1 _ADDLATA._RADD_LAT_2.ND RAA2 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_2.I48.MXNOE _ADDLATA.NET49[0] NCLKA
+  _ADDLATA._RADD_LAT_2.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2.I48.MXPOEN _ADDLATA.NET49[0] BCLKA
+  _ADDLATA._RADD_LAT_2.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_2.I50.MXNA1 RAA_P2[2] _ADDLATA.NET49[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_2.I50.MXPA1 RAA_P2[2] _ADDLATA.NET49[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_2.I55.MXNA1 _ADDLATA._RADD_LAT_2.I55.N1 RAA_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2.I55.MXNOE _ADDLATA.NET49[0] BCLKA
+  _ADDLATA._RADD_LAT_2.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2.I55.MXPA1 _ADDLATA._RADD_LAT_2.I55.P1 RAA_P2[2] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2.I55.MXPOEN _ADDLATA.NET49[0] NCLKA
+  _ADDLATA._RADD_LAT_2.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3.I47.MXNA1 _ADDLATA._RADD_LAT_3.ND RAA3 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3.I47.MXPA1 _ADDLATA._RADD_LAT_3.ND RAA3 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_3.I48.MXNOE _ADDLATA.NET40[2] NCLKA
+  _ADDLATA._RADD_LAT_3.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3.I48.MXPOEN _ADDLATA.NET40[2] BCLKA
+  _ADDLATA._RADD_LAT_3.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_3.I50.MXNA1 RAA_P2[3] _ADDLATA.NET40[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_3.I50.MXPA1 RAA_P2[3] _ADDLATA.NET40[2] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_3.I55.MXNA1 _ADDLATA._RADD_LAT_3.I55.N1 RAA_P2[3] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3.I55.MXNOE _ADDLATA.NET40[2] BCLKA
+  _ADDLATA._RADD_LAT_3.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3.I55.MXPA1 _ADDLATA._RADD_LAT_3.I55.P1 RAA_P2[3] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3.I55.MXPOEN _ADDLATA.NET40[2] NCLKA
+  _ADDLATA._RADD_LAT_3.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4.I47.MXNA1 _ADDLATA._RADD_LAT_4.ND RAA4 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4.I47.MXPA1 _ADDLATA._RADD_LAT_4.ND RAA4 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_4.I48.MXNOE _ADDLATA.NET40[1] NCLKA
+  _ADDLATA._RADD_LAT_4.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4.I48.MXPOEN _ADDLATA.NET40[1] BCLKA
+  _ADDLATA._RADD_LAT_4.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_4.I50.MXNA1 RAA_P2[4] _ADDLATA.NET40[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_4.I50.MXPA1 RAA_P2[4] _ADDLATA.NET40[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_4.I55.MXNA1 _ADDLATA._RADD_LAT_4.I55.N1 RAA_P2[4] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4.I55.MXNOE _ADDLATA.NET40[1] BCLKA
+  _ADDLATA._RADD_LAT_4.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4.I55.MXPA1 _ADDLATA._RADD_LAT_4.I55.P1 RAA_P2[4] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4.I55.MXPOEN _ADDLATA.NET40[1] NCLKA
+  _ADDLATA._RADD_LAT_4.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5.I47.MXNA1 _ADDLATA._RADD_LAT_5.ND RAA5 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5.I47.MXPA1 _ADDLATA._RADD_LAT_5.ND RAA5 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_5.I48.MXNOE _ADDLATA.NET40[0] NCLKA
+  _ADDLATA._RADD_LAT_5.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5.I48.MXPOEN _ADDLATA.NET40[0] BCLKA
+  _ADDLATA._RADD_LAT_5.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlata._radd_lat_5.I50.MXNA1 RAA_P2[5] _ADDLATA.NET40[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_5.I50.MXPA1 RAA_P2[5] _ADDLATA.NET40[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_5.I55.MXNA1 _ADDLATA._RADD_LAT_5.I55.N1 RAA_P2[5] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5.I55.MXNOE _ADDLATA.NET40[0] BCLKA
+  _ADDLATA._RADD_LAT_5.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5.I55.MXPA1 _ADDLATA._RADD_LAT_5.I55.P1 RAA_P2[5] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5.I55.MXPOEN _ADDLATA.NET40[0] NCLKA
+  _ADDLATA._RADD_LAT_5.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0.I47.MXNA1 _ADDLATB._CADD_LAT_0.ND CAB0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0.I47.MXPA1 _ADDLATB._CADD_LAT_0.ND CAB0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_0.I48.MXNOE _ADDLATB.NCA_P2[0] NCLKB
+  _ADDLATB._CADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0.I48.MXPOEN _ADDLATB.NCA_P2[0] BCLKB
+  _ADDLATB._CADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._cadd_lat_0.I50.MXNA1 CAB_P2[0] _ADDLATB.NCA_P2[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._cadd_lat_0.I50.MXPA1 CAB_P2[0] _ADDLATB.NCA_P2[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._cadd_lat_0.I55.MXNA1 _ADDLATB._CADD_LAT_0.I55.N1 CAB_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0.I55.MXNOE _ADDLATB.NCA_P2[0] BCLKB
+  _ADDLATB._CADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0.I55.MXPA1 _ADDLATB._CADD_LAT_0.I55.P1 CAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0.I55.MXPOEN _ADDLATB.NCA_P2[0] NCLKB
+  _ADDLATB._CADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1.I47.MXNA1 _ADDLATB._CADD_LAT_1.ND CAB1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1.I47.MXPA1 _ADDLATB._CADD_LAT_1.ND CAB1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_1.I48.MXNOE _ADDLATB.NCA_P2[1] NCLKB
+  _ADDLATB._CADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1.I48.MXPOEN _ADDLATB.NCA_P2[1] BCLKB
+  _ADDLATB._CADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._cadd_lat_1.I50.MXNA1 CAB_P2[1] _ADDLATB.NCA_P2[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._cadd_lat_1.I50.MXPA1 CAB_P2[1] _ADDLATB.NCA_P2[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._cadd_lat_1.I55.MXNA1 _ADDLATB._CADD_LAT_1.I55.N1 CAB_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1.I55.MXNOE _ADDLATB.NCA_P2[1] BCLKB
+  _ADDLATB._CADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1.I55.MXPA1 _ADDLATB._CADD_LAT_1.I55.P1 CAB_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1.I55.MXPOEN _ADDLATB.NCA_P2[1] NCLKB
+  _ADDLATB._CADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0.I47.MXNA1 _ADDLATB._LADD_LAT_0.ND LAB0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0.I47.MXPA1 _ADDLATB._LADD_LAT_0.ND LAB0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_0.I48.MXNOE _ADDLATB.NET52[1] NCLKB
+  _ADDLATB._LADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0.I48.MXPOEN _ADDLATB.NET52[1] BCLKB
+  _ADDLATB._LADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._ladd_lat_0.I50.MXNA1 LAB_P2[0] _ADDLATB.NET52[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._ladd_lat_0.I50.MXPA1 LAB_P2[0] _ADDLATB.NET52[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._ladd_lat_0.I55.MXNA1 _ADDLATB._LADD_LAT_0.I55.N1 LAB_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0.I55.MXNOE _ADDLATB.NET52[1] BCLKB
+  _ADDLATB._LADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0.I55.MXPA1 _ADDLATB._LADD_LAT_0.I55.P1 LAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0.I55.MXPOEN _ADDLATB.NET52[1] NCLKB
+  _ADDLATB._LADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1.I47.MXNA1 _ADDLATB._LADD_LAT_1.ND LAB1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1.I47.MXPA1 _ADDLATB._LADD_LAT_1.ND LAB1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_1.I48.MXNOE _ADDLATB.NET52[0] NCLKB
+  _ADDLATB._LADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1.I48.MXPOEN _ADDLATB.NET52[0] BCLKB
+  _ADDLATB._LADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._ladd_lat_1.I50.MXNA1 LAB_P2[1] _ADDLATB.NET52[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._ladd_lat_1.I50.MXPA1 LAB_P2[1] _ADDLATB.NET52[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._ladd_lat_1.I55.MXNA1 _ADDLATB._LADD_LAT_1.I55.N1 LAB_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1.I55.MXNOE _ADDLATB.NET52[0] BCLKB
+  _ADDLATB._LADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1.I55.MXPA1 _ADDLATB._LADD_LAT_1.I55.P1 LAB_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1.I55.MXPOEN _ADDLATB.NET52[0] NCLKB
+  _ADDLATB._LADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0.I47.MXNA1 _ADDLATB._RADD_LAT_0.ND RAB0 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0.I47.MXPA1 _ADDLATB._RADD_LAT_0.ND RAB0 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_0.I48.MXNOE _ADDLATB.NET49[2] NCLKB
+  _ADDLATB._RADD_LAT_0.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0.I48.MXPOEN _ADDLATB.NET49[2] BCLKB
+  _ADDLATB._RADD_LAT_0.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_0.I50.MXNA1 RAB_P2[0] _ADDLATB.NET49[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_0.I50.MXPA1 RAB_P2[0] _ADDLATB.NET49[2] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_0.I55.MXNA1 _ADDLATB._RADD_LAT_0.I55.N1 RAB_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0.I55.MXNOE _ADDLATB.NET49[2] BCLKB
+  _ADDLATB._RADD_LAT_0.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0.I55.MXPA1 _ADDLATB._RADD_LAT_0.I55.P1 RAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0.I55.MXPOEN _ADDLATB.NET49[2] NCLKB
+  _ADDLATB._RADD_LAT_0.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1.I47.MXNA1 _ADDLATB._RADD_LAT_1.ND RAB1 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1.I47.MXPA1 _ADDLATB._RADD_LAT_1.ND RAB1 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_1.I48.MXNOE _ADDLATB.NET49[1] NCLKB
+  _ADDLATB._RADD_LAT_1.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1.I48.MXPOEN _ADDLATB.NET49[1] BCLKB
+  _ADDLATB._RADD_LAT_1.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_1.I50.MXNA1 RAB_P2[1] _ADDLATB.NET49[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_1.I50.MXPA1 RAB_P2[1] _ADDLATB.NET49[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_1.I55.MXNA1 _ADDLATB._RADD_LAT_1.I55.N1 RAB_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1.I55.MXNOE _ADDLATB.NET49[1] BCLKB
+  _ADDLATB._RADD_LAT_1.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1.I55.MXPA1 _ADDLATB._RADD_LAT_1.I55.P1 RAB_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1.I55.MXPOEN _ADDLATB.NET49[1] NCLKB
+  _ADDLATB._RADD_LAT_1.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2.I47.MXNA1 _ADDLATB._RADD_LAT_2.ND RAB2 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2.I47.MXPA1 _ADDLATB._RADD_LAT_2.ND RAB2 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_2.I48.MXNOE _ADDLATB.NET49[0] NCLKB
+  _ADDLATB._RADD_LAT_2.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2.I48.MXPOEN _ADDLATB.NET49[0] BCLKB
+  _ADDLATB._RADD_LAT_2.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_2.I50.MXNA1 RAB_P2[2] _ADDLATB.NET49[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_2.I50.MXPA1 RAB_P2[2] _ADDLATB.NET49[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_2.I55.MXNA1 _ADDLATB._RADD_LAT_2.I55.N1 RAB_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2.I55.MXNOE _ADDLATB.NET49[0] BCLKB
+  _ADDLATB._RADD_LAT_2.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2.I55.MXPA1 _ADDLATB._RADD_LAT_2.I55.P1 RAB_P2[2] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2.I55.MXPOEN _ADDLATB.NET49[0] NCLKB
+  _ADDLATB._RADD_LAT_2.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3.I47.MXNA1 _ADDLATB._RADD_LAT_3.ND RAB3 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3.I47.MXPA1 _ADDLATB._RADD_LAT_3.ND RAB3 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_3.I48.MXNOE _ADDLATB.NET40[2] NCLKB
+  _ADDLATB._RADD_LAT_3.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3.I48.MXPOEN _ADDLATB.NET40[2] BCLKB
+  _ADDLATB._RADD_LAT_3.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_3.I50.MXNA1 RAB_P2[3] _ADDLATB.NET40[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_3.I50.MXPA1 RAB_P2[3] _ADDLATB.NET40[2] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_3.I55.MXNA1 _ADDLATB._RADD_LAT_3.I55.N1 RAB_P2[3] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3.I55.MXNOE _ADDLATB.NET40[2] BCLKB
+  _ADDLATB._RADD_LAT_3.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3.I55.MXPA1 _ADDLATB._RADD_LAT_3.I55.P1 RAB_P2[3] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3.I55.MXPOEN _ADDLATB.NET40[2] NCLKB
+  _ADDLATB._RADD_LAT_3.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4.I47.MXNA1 _ADDLATB._RADD_LAT_4.ND RAB4 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4.I47.MXPA1 _ADDLATB._RADD_LAT_4.ND RAB4 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_4.I48.MXNOE _ADDLATB.NET40[1] NCLKB
+  _ADDLATB._RADD_LAT_4.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4.I48.MXPOEN _ADDLATB.NET40[1] BCLKB
+  _ADDLATB._RADD_LAT_4.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_4.I50.MXNA1 RAB_P2[4] _ADDLATB.NET40[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_4.I50.MXPA1 RAB_P2[4] _ADDLATB.NET40[1] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_4.I55.MXNA1 _ADDLATB._RADD_LAT_4.I55.N1 RAB_P2[4] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4.I55.MXNOE _ADDLATB.NET40[1] BCLKB
+  _ADDLATB._RADD_LAT_4.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4.I55.MXPA1 _ADDLATB._RADD_LAT_4.I55.P1 RAB_P2[4] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4.I55.MXPOEN _ADDLATB.NET40[1] NCLKB
+  _ADDLATB._RADD_LAT_4.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5.I47.MXNA1 _ADDLATB._RADD_LAT_5.ND RAB5 VSS VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5.I47.MXPA1 _ADDLATB._RADD_LAT_5.ND RAB5 VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_5.I48.MXNOE _ADDLATB.NET40[0] NCLKB
+  _ADDLATB._RADD_LAT_5.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5.I48.MXPOEN _ADDLATB.NET40[0] BCLKB
+  _ADDLATB._RADD_LAT_5.ND VNWP P11LL_CKT W=0.345U L=0.04U
X_M_addlatb._radd_lat_5.I50.MXNA1 RAB_P2[5] _ADDLATB.NET40[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_5.I50.MXPA1 RAB_P2[5] _ADDLATB.NET40[0] VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_5.I55.MXNA1 _ADDLATB._RADD_LAT_5.I55.N1 RAB_P2[5] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5.I55.MXNOE _ADDLATB.NET40[0] BCLKB
+  _ADDLATB._RADD_LAT_5.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5.I55.MXPA1 _ADDLATB._RADD_LAT_5.I55.P1 RAB_P2[5] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5.I55.MXPOEN _ADDLATB.NET40[0] NCLKB
+  _ADDLATB._RADD_LAT_5.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_cka.I138.MXNA1 RET RET1N _CKA.I138.N1 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXNA2 _CKA.I138.N1 TIEHIA VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXPA1 RET RET1N VDDCE VNWC P11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXPA2 RET TIEHIA VDDCE VNWC P11LL_CKT W=0.565U L=0.04U
X_M_cka.I239_0.MXNA1 _CKA.NCAA_P2[0] CAA_P2[0] VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_cka.I239_0.MXPA1 _CKA.NCAA_P2[0] CAA_P2[0] VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka.I239_1.MXNA1 _CKA.NCAA_P2[1] CAA_P2[1] VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_cka.I239_1.MXPA1 _CKA.NCAA_P2[1] CAA_P2[1] VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka.I241.MXNA1 _CKA.NET109 _CKA.GTPA_SA VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I241.MXNA2 _CKA.NET109 _CKA.GTPA_SA_DLY VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka.I241.MXPA1 _CKA.NET109 _CKA.GTPA_SA _CKA.I241.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_cka.I241.MXPA2 _CKA.I241.P1 _CKA.GTPA_SA_DLY VDDPE VNWP P11LL_CKT W=0.774U
+  L=0.04U
X_M_cka.I242.MXNA1 _CKA.I242.N1 _CKA.NET0125 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I242.MXNOE _CKA.NET0119 _CKA.NET0125 _CKA.I242.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I242.MXPA1 _CKA.I242.P1 _CKA.NET0125 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I242.MXPOEN _CKA.NET0119 _CKA.NET0125 _CKA.I242.P1 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I244_0.MXNA1 _CKA.ICAA_P2[0] _CKA.NCAA_P2[0] VSS VPW N11LL_CKT W=0.26U
+  L=0.04U
X_M_cka.I244_0.MXPA1 _CKA.ICAA_P2[0] _CKA.NCAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.485U L=0.04U
X_M_cka.I244_1.MXNA1 _CKA.ICAA_P2[1] _CKA.NCAA_P2[1] VSS VPW N11LL_CKT W=0.26U
+  L=0.04U
X_M_cka.I244_1.MXPA1 _CKA.ICAA_P2[1] _CKA.NCAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.485U L=0.04U
X_M_cka.I245.MXNA1 _CKA.NDFTNRETA RET VSSE VPW N11LL_CKT W=0.655U L=0.04U
X_M_cka.I245.MXNA2 _CKA.NDFTNRETA DFTRAMBYPA VSSE VPW N11LL_CKT W=0.655U
+  L=0.04U
X_M_cka.I245.MXPA1 _CKA.NDFTNRETA RET _CKA.I245.P1 VNWC P11LL_CKT W=1.845U
+  L=0.04U
X_M_cka.I245.MXPA2 _CKA.I245.P1 DFTRAMBYPA VDDCE VNWC P11LL_CKT W=1.845U
+  L=0.04U
X_M_cka.I246.MXNA1 _CKA.NET0125 RET VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I246.MXNA2 _CKA.NET0125 GTPA VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I246.MXPA1 _CKA.NET0125 RET _CKA.I246.P1 VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I246.MXPA2 _CKA.I246.P1 GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I252.MXN3 _CKA.I252.NET50 _CKA.I252.NDI VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXN4 _CKA.I252.NDI _CKA.GTPA_SA VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka.I252.MXN8 _CKA.GTPA_SA_DLY _CKA.I252.NDI _CKA.I252.NET50 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I252.MXP0 _CKA.GTPA_SA_DLY _CKA.I252.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXP1 _CKA.I252.NDI _CKA.GTPA_SA VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXP2 VDDPE _CKA.GTPA_SA VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_cka.I32.MXNA1 NCLKA GTPA VSSE VPW N11LL_CKT W=1.275U L=0.04U
X_M_cka.I32.MXPA1 NCLKA GTPA VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cka.I4.MXNA1 _CKA.NICLK GTPA VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I4.MXPA1 _CKA.NICLK GTPA VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_M_cka.I5.MXNA1 BCLKA _CKA.NICLK VSSE VPW N11LL_CKT W=1.275U L=0.04U
X_M_cka.I5.MXPA1 BCLKA _CKA.NICLK VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cka.I51.MXNA1 _CKA.NGTPA GTPA VSS VPW N11LL_CKT W=0.91U L=0.04U
X_M_cka.I51.MXPA1 _CKA.NGTPA GTPA VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_cka.I52.MXNA1 DFTRETA _CKA.NDFTNRETA VSSE VPW N11LL_CKT W=3.7U L=0.04U
X_M_cka.I52.MXPA1 DFTRETA _CKA.NDFTNRETA VDDCE VNWC P11LL_CKT W=5.54U L=0.04U
X_M_cka.I60.MXNA1 NSAE _CKA.NET204 VSS VPW N11LL_CKT W=7.94U L=0.04U
X_M_cka.I60.MXPA1 NSAE _CKA.NET204 VDDPE VNWP P11LL_CKT W=7.1U L=0.04U
X_M_cka.I61.MXNA1 SAPRECH _CKA.NSAPRECH VSSE VPW N11LL_CKT W=5.68U L=0.04U
X_M_cka.I61.MXPA1 SAPRECH _CKA.NSAPRECH VDDPE VNWP P11LL_CKT W=4U L=0.04U
X_M_cka.I64.MXNA1 _CKA.NSAPRECH _CKA.ISAPRECH VSSE VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_cka.I64.MXPA1 _CKA.NSAPRECH _CKA.ISAPRECH VDDPE VNWP P11LL_CKT W=2.02U
+  L=0.04U
X_M_cka.I7.MXNA1 _CKA.DFTCLKA NCLKA VSSE VPW N11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXNA2 _CKA.DFTCLKA DFTRAMBYPA VSSE VPW N11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXPA1 _CKA.DFTCLKA NCLKA _CKA.I7.P1 VNWP P11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXPA2 _CKA.I7.P1 DFTRAMBYPA VDDPE VNWP P11LL_CKT W=0.905U L=0.04U
X_M_cka.I77.MXNA1 _CKA.ISAPRECH _CKA.NET0119 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka.I77.MXNA2 _CKA.ISAPRECH GTPA VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I77.MXPA1 _CKA.ISAPRECH _CKA.NET0119 _CKA.I77.P1 VNWP P11LL_CKT W=0.5U
+  L=0.04U
X_M_cka.I77.MXPA2 _CKA.I77.P1 GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I80.MXNA1 _CKA.NET204 _CKA.NET109 VSS VPW N11LL_CKT W=0.868U L=0.04U
X_M_cka.I80.MXPA1 _CKA.NET204 _CKA.NET109 VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_M_cka.MXN0 TIELOCDA TIEHIA VSSE VPW N11LL_CKT W=2.27U L=0.04U
X_M_cka.MXN1 TIELOFPA TIEHIA VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_cka.RF2YDec2to4a.I16_0.MXNA1 NYPACLK[0] _CKA.RF2YDEC2TO4A.NET37[3] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_0.MXPA1 NYPACLK[0] _CKA.RF2YDEC2TO4A.NET37[3] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_1.MXNA1 NYPACLK[1] _CKA.RF2YDEC2TO4A.NET37[2] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_1.MXPA1 NYPACLK[1] _CKA.RF2YDEC2TO4A.NET37[2] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_2.MXNA1 NYPACLK[2] _CKA.RF2YDEC2TO4A.NET37[1] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_2.MXPA1 NYPACLK[2] _CKA.RF2YDEC2TO4A.NET37[1] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_3.MXNA1 NYPACLK[3] _CKA.RF2YDEC2TO4A.NET37[0] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_3.MXPA1 NYPACLK[3] _CKA.RF2YDEC2TO4A.NET37[0] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I17_0.MXNA1 _CKA.RF2YDEC2TO4A.NET37[3]
+  _CKA.RF2YDEC2TO4A.NET17[3] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_0.MXPA1 _CKA.RF2YDEC2TO4A.NET37[3]
+  _CKA.RF2YDEC2TO4A.NET17[3] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_1.MXNA1 _CKA.RF2YDEC2TO4A.NET37[2]
+  _CKA.RF2YDEC2TO4A.NET17[2] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_1.MXPA1 _CKA.RF2YDEC2TO4A.NET37[2]
+  _CKA.RF2YDEC2TO4A.NET17[2] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_2.MXNA1 _CKA.RF2YDEC2TO4A.NET37[1]
+  _CKA.RF2YDEC2TO4A.NET17[1] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_2.MXPA1 _CKA.RF2YDEC2TO4A.NET37[1]
+  _CKA.RF2YDEC2TO4A.NET17[1] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_3.MXNA1 _CKA.RF2YDEC2TO4A.NET37[0]
+  _CKA.RF2YDEC2TO4A.NET17[0] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_3.MXPA1 _CKA.RF2YDEC2TO4A.NET37[0]
+  _CKA.RF2YDEC2TO4A.NET17[0] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_0.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXPA2 _CKA.RF2YDEC2TO4A.I8_0.P1 _CKA.ICAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.ICAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.NCAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.ICAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_1.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXPA2 _CKA.RF2YDEC2TO4A.I8_1.P1 _CKA.NCAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.NCAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.ICAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.NCAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_2.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXPA2 _CKA.RF2YDEC2TO4A.I8_2.P1 _CKA.ICAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_3.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXPA2 _CKA.RF2YDEC2TO4A.I8_3.P1 _CKA.NCAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXN0 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_0.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXN1 _CKA.RF2YDEC2TO4A.I9_0.N2
+  _CKA.RF2YDEC2TO4A.IDEC[0] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXNA1 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_0.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXNA2 _CKA.RF2YDEC2TO4A.I9_0.N1
+  _CKA.RF2YDEC2TO4A.IDEC[0] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXPA1 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXPA2 _CKA.RF2YDEC2TO4A.NET17[3]
+  _CKA.RF2YDEC2TO4A.IDEC[0] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXN0 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_1.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXN1 _CKA.RF2YDEC2TO4A.I9_1.N2
+  _CKA.RF2YDEC2TO4A.IDEC[1] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXNA1 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_1.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXNA2 _CKA.RF2YDEC2TO4A.I9_1.N1
+  _CKA.RF2YDEC2TO4A.IDEC[1] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXPA1 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXPA2 _CKA.RF2YDEC2TO4A.NET17[2]
+  _CKA.RF2YDEC2TO4A.IDEC[1] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXN0 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_2.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXN1 _CKA.RF2YDEC2TO4A.I9_2.N2
+  _CKA.RF2YDEC2TO4A.IDEC[2] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXNA1 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_2.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXNA2 _CKA.RF2YDEC2TO4A.I9_2.N1
+  _CKA.RF2YDEC2TO4A.IDEC[2] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXPA1 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXPA2 _CKA.RF2YDEC2TO4A.NET17[1]
+  _CKA.RF2YDEC2TO4A.IDEC[2] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXN0 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_3.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXN1 _CKA.RF2YDEC2TO4A.I9_3.N2
+  _CKA.RF2YDEC2TO4A.IDEC[3] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXNA1 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_3.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXNA2 _CKA.RF2YDEC2TO4A.I9_3.N1
+  _CKA.RF2YDEC2TO4A.IDEC[3] VSS VPW N11LL_CKT W=0.33U L=0.04U
