* 
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Single Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.299um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 16 -b\
* Configuration: mux off -bus_notation on -check_instname on -diode\
* Configuration: s on -drive 6 -ema on -frequency 1.0 -instname RAM\
* Configuration: SP128X16 -left_bus_delim "[" -mux 2 -mvt "" -name_\
* Configuration: case upper -power_type otc -prefix "" -pwr_gnd_ren\
* Configuration: ame vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention o\
* Configuration: n -right_bus_delim "]" -ser none -site_def off -to\
* Configuration: p_layer m5-m10 -words 128 -write_mask on -write_th\
* Configuration: ru off -corners ff_1p10v_1p10v_0c,ff_1p10v_1p10v_1\
* Configuration: 25c,ff_1p10v_1p10v_m40c,ff_1p21v_1p21v_0c,ff_1p21v\
* Configuration: _1p21v_125c,ff_1p21v_1p21v_m40c,ff_1p26v_1p26v_0c,\
* Configuration: ff_1p26v_1p26v_125c,ff_1p26v_1p26v_85c,ff_1p26v_1p\
* Configuration: 26v_m40c,ss_0p90v_0p90v_0c,ss_0p90v_0p90v_125c,ss_\
* Configuration: 0p90v_0p90v_m40c,ss_0p99v_0p99v_0c,ss_0p99v_0p99v_\
* Configuration: 125c,ss_0p99v_0p99v_m40c,ss_1p08v_1p08v_0c,ss_1p08\
* Configuration: v_1p08v_125c,ss_1p08v_1p08v_m40c,tt_1p00v_1p00v_12\
* Configuration: 5c,tt_1p00v_1p00v_25c,tt_1p00v_1p00v_85c,tt_1p10v_\
* Configuration: 1p10v_125c,tt_1p10v_1p10v_25c,tt_1p10v_1p10v_85c,t\
* Configuration: t_1p20v_1p20v_125c,tt_1p20v_1p20v_25c,tt_1p20v_1p2\
* Configuration: 0v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RAMSP128X16BOTCAP2X2 D0 D1 LOG0 Q0 Q1 TD0 TD1 TWEN0 TWEN1 VDDCE VDDPE
+  VNWP VPW VSS VSSE WEN0 WEN1 WENY0 WENY1
** RAMSP128X16BOTCAP2X2: 8 flat devices **
DI13.D_Diode_X_dio VPW TD0 NDIO11LL AREA=0.035P PJ=0.78U
DI17.D_Diode_X_dio VPW D0 NDIO11LL AREA=0.035P PJ=0.78U
DI18.D_Diode_X_dio VPW TWEN0 NDIO11LL AREA=0.035P PJ=0.78U
DI19.D_Diode_X_dio VPW WEN0 NDIO11LL AREA=0.035P PJ=0.78U
DI77.D_Diode_X_dio VPW WEN1 NDIO11LL AREA=0.035P PJ=0.78U
DI78.D_Diode_X_dio VPW TWEN1 NDIO11LL AREA=0.035P PJ=0.78U
DI80.D_Diode_X_dio VPW D1 NDIO11LL AREA=0.035P PJ=0.78U
DI82.D_Diode_X_dio VPW TD1 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP128X16BOTCAP2X2
****
.SUBCKT RAMSP128X16BOTCAP2X2_RPT D0 D1 LOG0 Q0 Q1 VDDCE VNWP VPW WEN0 WEN1
+  WENY0 WENY1
** RAMSP128X16BOTCAP2X2_RPT: 8 flat devices **
XI0 D0 D1 LOG0 Q0 Q1 LOG0 LOG0 LOG0 LOG0 VDDCE VNWP VNWP VPW VPW VPW WEN0 WEN1
+  WENY0 WENY1 RAMSP128X16BOTCAP2X2
.ENDS RAMSP128X16BOTCAP2X2_RPT
****
.SUBCKT RAMSP128X16MIDBOT_BIST CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2
+  EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LOG0 NWCLK PEN PENSI PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0
+  TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5
+  VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP128X16MIDBOT_BIST: 60 flat devices **
DI100.D_Diode_X_dio VPW FCA1_3 NDIO11LL AREA=0.035P PJ=0.78U
DI102.D_Diode_X_dio VPW CRE1 NDIO11LL AREA=0.035P PJ=0.78U
DI104.D_Diode_X_dio VPW RA5 NDIO11LL AREA=0.035P PJ=0.78U
DI106.D_Diode_X_dio VPW RA3 NDIO11LL AREA=0.035P PJ=0.78U
DI107.D_Diode_X_dio VPW RA4 NDIO11LL AREA=0.035P PJ=0.78U
DI108.D_Diode_X_dio VPW LA2 NDIO11LL AREA=0.035P PJ=0.78U
DI110.D_Diode_X_dio VPW LA1 NDIO11LL AREA=0.035P PJ=0.78U
DI111.D_Diode_X_dio VPW RA2 NDIO11LL AREA=0.035P PJ=0.78U
DI112.D_Diode_X_dio VPW RA1 NDIO11LL AREA=0.035P PJ=0.78U
DI114.D_Diode_X_dio VPW LA0 NDIO11LL AREA=0.035P PJ=0.78U
DI115.D_Diode_X_dio VPW CA2 NDIO11LL AREA=0.035P PJ=0.78U
DI117.D_Diode_X_dio VPW RA0 NDIO11LL AREA=0.035P PJ=0.78U
DI118.D_Diode_X_dio VPW TPEN NDIO11LL AREA=0.035P PJ=0.78U
DI119.D_Diode_X_dio VPW PEN NDIO11LL AREA=0.035P PJ=0.78U
DI120.D_Diode_X_dio VPW TGWEN NDIO11LL AREA=0.035P PJ=0.78U
DI121.D_Diode_X_dio VPW TCEN NDIO11LL AREA=0.035P PJ=0.78U
DI122.D_Diode_X_dio VPW CA0 NDIO11LL AREA=0.035P PJ=0.78U
DI123.D_Diode_X_dio VPW PENSI NDIO11LL AREA=0.035P PJ=0.78U
DI124.D_Diode_X_dio VPW CA1 NDIO11LL AREA=0.035P PJ=0.78U
DI125.D_Diode_X_dio VPW TLA1 NDIO11LL AREA=0.035P PJ=0.78U
DI126.D_Diode_X_dio VPW TLA2 NDIO11LL AREA=0.035P PJ=0.78U
DI127.D_Diode_X_dio VPW TRA4 NDIO11LL AREA=0.035P PJ=0.78U
DI128.D_Diode_X_dio VPW TRA5 NDIO11LL AREA=0.035P PJ=0.78U
DI129.D_Diode_X_dio VPW TRA3 NDIO11LL AREA=0.035P PJ=0.78U
DI130.D_Diode_X_dio VPW TRA2 NDIO11LL AREA=0.035P PJ=0.78U
DI131.D_Diode_X_dio VPW TLA0 NDIO11LL AREA=0.035P PJ=0.78U
DI132.D_Diode_X_dio VPW TCA2 NDIO11LL AREA=0.035P PJ=0.78U
DI133.D_Diode_X_dio VPW TRA0 NDIO11LL AREA=0.035P PJ=0.78U
DI134.D_Diode_X_dio VPW TRA1 NDIO11LL AREA=0.035P PJ=0.78U
DI135.D_Diode_X_dio VPW TCA1 NDIO11LL AREA=0.035P PJ=0.78U
DI136.D_Diode_X_dio VPW TCA0 NDIO11LL AREA=0.035P PJ=0.78U
DI137.D_Diode_X_dio VPW GWEN NDIO11LL AREA=0.035P PJ=0.78U
DI138.D_Diode_X_dio VPW CEN NDIO11LL AREA=0.035P PJ=0.78U
DI139.D_Diode_X_dio VPW RDT NDIO11LL AREA=0.035P PJ=0.78U
DI140.D_Diode_X_dio VPW TEN NDIO11LL AREA=0.035P PJ=0.78U
DI142.D_Diode_X_dio VPW DFTRAMBYP NDIO11LL AREA=0.035P PJ=0.78U
DI146.D_Diode_X_dio VPW EMA2 NDIO11LL AREA=0.035P PJ=0.78U
DI147.D_Diode_X_dio VPW EMA1 NDIO11LL AREA=0.035P PJ=0.78U
DI148.D_Diode_X_dio VPW EMA0 NDIO11LL AREA=0.035P PJ=0.78U
DI151.D_Diode_X_dio VPW EMAW0 NDIO11LL AREA=0.035P PJ=0.78U
DI152.D_Diode_X_dio VPW EMAW1 NDIO11LL AREA=0.035P PJ=0.78U
DI154.D_Diode_X_dio VPW CLK NDIO11LL AREA=0.035P PJ=0.78U
DI157.D_Diode_X_dio VPW SE NDIO11LL AREA=0.035P PJ=0.78U
DI158.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
DI159.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
DI160.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
DI61.D_Diode_X_dio VPW FCA1_0 NDIO11LL AREA=0.035P PJ=0.78U
DI65.D_Diode_X_dio VPW FCA1_1 NDIO11LL AREA=0.035P PJ=0.78U
DI66.D_Diode_X_dio VPW FCA1_2 NDIO11LL AREA=0.035P PJ=0.78U
DI77.D_Diode_X_dio VPW FCA2_6 NDIO11LL AREA=0.035P PJ=0.78U
DI90.D_Diode_X_dio VPW FCA2_4 NDIO11LL AREA=0.035P PJ=0.78U
DI91.D_Diode_X_dio VPW FCA2_5 NDIO11LL AREA=0.035P PJ=0.78U
DI92.D_Diode_X_dio VPW FCA2_2 NDIO11LL AREA=0.035P PJ=0.78U
DI93.D_Diode_X_dio VPW FCA2_1 NDIO11LL AREA=0.035P PJ=0.78U
DI94.D_Diode_X_dio VPW FCA2_3 NDIO11LL AREA=0.035P PJ=0.78U
DI95.D_Diode_X_dio VPW FCA1_6 NDIO11LL AREA=0.035P PJ=0.78U
DI96.D_Diode_X_dio VPW FCA1_4 NDIO11LL AREA=0.035P PJ=0.78U
DI97.D_Diode_X_dio VPW FCA1_5 NDIO11LL AREA=0.035P PJ=0.78U
DI98.D_Diode_X_dio VPW FCA2_0 NDIO11LL AREA=0.035P PJ=0.78U
DI99.D_Diode_X_dio VPW CRE2 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP128X16MIDBOT_BIST
****
.SUBCKT RAMSP128X16MIDBOT_BIST_WRAPT CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK
+  CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1
+  EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1
+  LAY2 LOG0 NWCLK PEN PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2
+  TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP128X16MIDBOT_BIST_WRAPT: 60 flat devices **
XI0 CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R
+  DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1
+  FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4
+  FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN PENSI
+  PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN
+  TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE VDDC_L VDDC_R
+  VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE RAMSP128X16MIDBOT_BIST
.ENDS RAMSP128X16MIDBOT_BIST_WRAPT
****
.SUBCKT RAMSP128X16BOTCORNER LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP128X16BOTCORNER: 2 flat devices **
DI74.D_Diode_X_dio VPW PSI NDIO11LL AREA=0.035P PJ=0.78U
DI85.D_Diode_X_dio VPW SI NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP128X16BOTCORNER
****
.SUBCKT RAMSP128X16BOTCORNER_WRAPT LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP128X16BOTCORNER_WRAPT: 2 flat devices **
XI0 LOG0 PSI SI VNWC VNWP VPW VSS RAMSP128X16BOTCORNER
.ENDS RAMSP128X16BOTCORNER_WRAPT
****
.SUBCKT RAMSP128X16BOTCAPROW CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2
+  D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6
+  D1_7 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2
+  EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LOG0 NWCLK PEN PENSI PENSO PSI_0 PSI_1 PSO0 PSO1 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4
+  Q0_5 Q0_6 Q0_7 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 RA0 RA1 RA2 RA3 RA4
+  RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SI_0
+  SI_1 SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1
+  TRA2 TRA3 TRA4 TRA5 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC_0 VNWC_1 VNWC_2 VNWP
+  VPW VSSE WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1 WENY1_2 WENY1_3
+  WENY1_4 WENY1_5 WENY1_6 WENY1_7
** RAMSP128X16BOTCAPROW: 128 flat devices **
XCENTRE CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP
+  DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN
+  PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN TGWEN TLA0
+  TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE_4 VDDC_L VDDC_R VDDPE
+  VDDP_CLKGEN VNWC_1 VNWP VPW VPW VSSE RAMSP128X16MIDBOT_BIST_WRAPT
XLEFT LOG0 PSI_0 SI_0 VNWC_0 VNWP VPW VPW RAMSP128X16BOTCORNER_WRAPT
XLEFT_COL_0 D0_0 D1_0 LOG0 Q0_0 Q1_0 VDDCE_0 VNWP VPW WEN0_0 WEN1_0 WENY0_0
+  WENY1_0 RAMSP128X16BOTCAP2X2_RPT
XLEFT_COL_1 D0_1 D1_1 LOG0 Q0_1 Q1_1 VDDCE_1 VNWP VPW WEN0_1 WEN1_1 WENY0_1
+  WENY1_1 RAMSP128X16BOTCAP2X2_RPT
XLEFT_COL_2 D0_2 D1_2 LOG0 Q0_2 Q1_2 VDDCE_2 VNWP VPW WEN0_2 WEN1_2 WENY0_2
+  WENY1_2 RAMSP128X16BOTCAP2X2_RPT
XLEFT_COL_3 D0_3 D1_3 LOG0 Q0_3 Q1_3 VDDCE_3 VNWP VPW WEN0_3 WEN1_3 WENY0_3
+  WENY1_3 RAMSP128X16BOTCAP2X2_RPT
XRIGHT LOG0 PSI_1 SI_1 VNWC_2 VNWP VPW VPW RAMSP128X16BOTCORNER_WRAPT
XRIGHT_COL_0 D0_4 D1_4 LOG0 Q0_4 Q1_4 VDDCE_5 VNWP VPW WEN0_4 WEN1_4 WENY0_4
+  WENY1_4 RAMSP128X16BOTCAP2X2_RPT
XRIGHT_COL_1 D0_5 D1_5 LOG0 Q0_5 Q1_5 VDDCE_6 VNWP VPW WEN0_5 WEN1_5 WENY0_5
+  WENY1_5 RAMSP128X16BOTCAP2X2_RPT
XRIGHT_COL_2 D0_6 D1_6 LOG0 Q0_6 Q1_6 VDDCE_7 VNWP VPW WEN0_6 WEN1_6 WENY0_6
+  WENY1_6 RAMSP128X16BOTCAP2X2_RPT
XRIGHT_COL_3 D0_7 D1_7 LOG0 Q0_7 Q1_7 VDDCE_8 VNWP VPW WEN0_7 WEN1_7 WENY0_7
+  WENY1_7 RAMSP128X16BOTCAP2X2_RPT
.ENDS RAMSP128X16BOTCAPROW
****
.SUBCKT RAMSP128X16COLM2X2_BIST_WM BL0 BL1 BL2 BL3 BLPRECH D0 D1 DFTRAMBYP
+  DUM_NWCLK_L DUM_NWCLK_R DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R
+  DUM_SEL_TD_L DUM_SEL_TD_R DWL LOG0 NACT_CC NBL0 NBL1 NBL2 NBL3 NSAE NWCLK
+  NWCLK_WT NYR0 NYR1 SAO0 SAO1 SAPRECH SEL_D SEL_SI SEL_TD SI SO TD0 TD1 TE
+  TWEN0 TWEN0_PRG TWEN1 TWEN1_PRG TWENL TWENR VDDC VDDCE VDDPE VNWC VNWP VPW
+  VSS VSSE WEN0 WEN0_PRG WEN1 WEN1_PRG WENL WENR WENY0 WENY1 YW0 YW1
** RAMSP128X16COLM2X2_BIST_WM: 265 flat devices **
X_M_cd.I34.MXNA1 _CD.NBLPRECH BLPRECH VSS VPW N11LL_CKT W=0.395U L=0.04U
X_M_cd.I34.MXPA1 _CD.NBLPRECH BLPRECH VDDPE VNWP P11LL_CKT W=0.87U L=0.04U
X_M_cd.I46.MXNA1 _CD.SAE NSAE VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_cd.I46.MXPA1 _CD.SAE NSAE VDDPE VNWP P11LL_CKT W=0.53U L=0.04U
X_M_cd.I56.MXNA1 _CD.NSAPRECH SAPRECH _CD.I56.N1 VPW N11LL_CKT W=0.21U L=0.04U
X_M_cd.I56.MXNA2 _CD.I56.N1 NSAE VSS VPW N11LL_CKT W=0.21U L=0.04U
X_M_cd.I56.MXPA1 _CD.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.63U L=0.04U
X_M_cd.I56.MXPA2 _CD.NSAPRECH NSAE VDDPE VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cd._cdrw0._mx0.MXN0 NBL0 YW0 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXN1 BL0 YW0 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXP1 NBL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP10 _CD._CDRW0._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx0.MXP3 _CD.NSD0 NYR0 NBL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP4 _CD.SD0 NYR0 BL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP5 NBL0 BL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx0.MXP7 BL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP8 NBL0 _CD.NBLPRECH BL0 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP9 BL0 NBL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXN0 NBL1 YW1 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXN1 BL1 YW1 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXP1 NBL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP10 _CD._CDRW0._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx1.MXP3 _CD.NSD0 NYR1 NBL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP4 _CD.SD0 NYR1 BL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP5 NBL1 BL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXP7 BL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP8 NBL1 _CD.NBLPRECH BL1 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP9 BL1 NBL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXN0 NBL2 YW0 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXN1 BL2 YW0 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXP1 NBL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP10 _CD._CDRW1._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx0.MXP3 _CD.NSD1 NYR0 NBL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP4 _CD.SD1 NYR0 BL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP5 NBL2 BL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXP7 BL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP8 NBL2 _CD.NBLPRECH BL2 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP9 BL2 NBL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXN0 NBL3 YW1 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXN1 BL3 YW1 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXP1 NBL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP10 _CD._CDRW1._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx1.MXP3 _CD.NSD1 NYR1 NBL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP4 _CD.SD1 NYR1 BL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP5 NBL3 BL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXP7 BL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP8 NBL3 _CD.NBLPRECH BL3 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP9 BL3 NBL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._sa0.MXN17 _CD.NSD0 _CD.SD0 _CD.NET125 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa0.MXN18 _CD.NET125 _CD.SAE VSS VPW N11LL_CKT W=0.93U L=0.04U
X_M_cd._sa0.MXN19 _CD.SD0 _CD.NSD0 _CD.NET125 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa0.MXP24 _CD.NSD0 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP25 _CD.NSD0 _CD.NSAPRECH _CD.SD0 VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP26 _CD.SD0 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP27 _CD.NSD0 _CD.SD0 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa0.MXP28 _CD.SD0 _CD.NSD0 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXN17 _CD.NSD1 _CD.SD1 _CD.NET116 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa1.MXN18 _CD.NET116 _CD.SAE VSS VPW N11LL_CKT W=0.93U L=0.04U
X_M_cd._sa1.MXN19 _CD.SD1 _CD.NSD1 _CD.NET116 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa1.MXP24 _CD.NSD1 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP25 _CD.NSD1 _CD.NSAPRECH _CD.SD1 VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP26 _CD.SD1 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP27 _CD.NSD1 _CD.SD1 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXP28 _CD.SD1 _CD.NSD1 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._salat0.I62.MXNA1 SAO0 _CD._SALAT0.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat0.I62.MXPA1 SAO0 _CD._SALAT0.SD_LAT VDDPE VNWP P11LL_CKT W=0.61U
+  L=0.04U
X_M_cd._salat0.I68.MXNA1 _CD._SALAT0.WCLK_WT NWCLK_WT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat0.I68.MXPA1 _CD._SALAT0.WCLK_WT NWCLK_WT VDDPE VNWP P11LL_CKT
+  W=0.21U L=0.04U
X_M_cd._salat0.I69.MXNA1 _CD._SALAT0.I69.N1 NET141 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._salat0.I69.MXNOE _CD._SALAT0.NSD_LAT _CD._SALAT0.WCLK_WT
+  _CD._SALAT0.I69.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat0.I69.MXPA1 _CD._SALAT0.I69.P1 NET141 VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_cd._salat0.I69.MXPOEN _CD._SALAT0.NSD_LAT NWCLK_WT _CD._SALAT0.I69.P1 VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat0.I70.MXNA1 _CD._SALAT0.I70.N1 _CD._SALAT0.SD_LAT VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat0.I70.MXNOE _CD._SALAT0.NSD_LAT NWCLK_WT _CD._SALAT0.I70.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat0.I70.MXPA1 _CD._SALAT0.I70.P1 _CD._SALAT0.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat0.I70.MXPOEN _CD._SALAT0.NSD_LAT _CD._SALAT0.WCLK_WT
+  _CD._SALAT0.I70.P1 VNWP P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat0.I82.MXNA1 _CD._SALAT0.NLAT_E _CD.SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat0.I82.MXPA1 _CD._SALAT0.NLAT_E _CD.SAE VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_cd._salat0.MXN8 _CD._SALAT0.N1B _CD._SALAT0.NSD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat0.MXN9 _CD._SALAT0.SD_LAT _CD._SALAT0.NLAT_E _CD._SALAT0.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat0.MXP6 _CD._SALAT0.SD_LAT _CD.SAE _CD._SALAT0.P1B VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat0.MXP7 _CD._SALAT0.P1B _CD._SALAT0.NSD_LAT VDDPE VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat0.MXPs _CD._SALAT0.SD_LAT _CD.NSD0 _CD._SALAT0.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat0.MX_ndmy _CD._SALAT0.NSD_DUM _CD.SD0 _CD._SALAT0.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat0.MX_nlat _CD._SALAT0.N1A _CD.SAE VSS VPW N11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat0.MX_pdmy _CD._SALAT0.NSD_DUM _CD.SD0 _CD._SALAT0.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat0.MX_pnsae _CD._SALAT0.P1A _CD._SALAT0.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat0.MX_sd_n _CD._SALAT0.SD_LAT _CD.NSD0 _CD._SALAT0.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I62.MXNA1 SAO1 _CD._SALAT1.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat1.I62.MXPA1 SAO1 _CD._SALAT1.SD_LAT VDDPE VNWP P11LL_CKT W=0.61U
+  L=0.04U
X_M_cd._salat1.I68.MXNA1 _CD._SALAT1.WCLK_WT NWCLK_WT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.I68.MXPA1 _CD._SALAT1.WCLK_WT NWCLK_WT VDDPE VNWP P11LL_CKT
+  W=0.21U L=0.04U
X_M_cd._salat1.I69.MXNA1 _CD._SALAT1.I69.N1 D_WT VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._salat1.I69.MXNOE _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I69.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I69.MXPA1 _CD._SALAT1.I69.P1 D_WT VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.I69.MXPOEN _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I69.P1 VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXNA1 _CD._SALAT1.I70.N1 _CD._SALAT1.SD_LAT VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXNOE _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I70.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXPA1 _CD._SALAT1.I70.P1 _CD._SALAT1.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXPOEN _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I70.P1 VNWP P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I82.MXNA1 _CD._SALAT1.NLAT_E _CD.SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat1.I82.MXPA1 _CD._SALAT1.NLAT_E _CD.SAE VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_cd._salat1.MXN8 _CD._SALAT1.N1B _CD._SALAT1.NSD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.MXN9 _CD._SALAT1.SD_LAT _CD._SALAT1.NLAT_E _CD._SALAT1.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat1.MXP6 _CD._SALAT1.SD_LAT _CD.SAE _CD._SALAT1.P1B VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXP7 _CD._SALAT1.P1B _CD._SALAT1.NSD_LAT VDDPE VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXPs _CD._SALAT1.SD_LAT _CD.NSD1 _CD._SALAT1.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat1.MX_ndmy _CD._SALAT1.NSD_DUM _CD.SD1 _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.MX_nlat _CD._SALAT1.N1A _CD.SAE VSS VPW N11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.MX_pdmy _CD._SALAT1.NSD_DUM _CD.SD1 _CD._SALAT1.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_pnsae _CD._SALAT1.P1A _CD._SALAT1.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_sd_n _CD._SALAT1.SD_LAT _CD.NSD1 _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._wl_load.MXNpgl VSS DWL VSS VPW N11LL_CKT W=1.2U L=0.06U
X_M_wr.I183.MXNA1 NET141 _WR.ND_LAT0 VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I183.MXPA1 NET141 _WR.ND_LAT0 VDDPE VNWP P11LL_CKT W=0.255U L=0.04U
X_M_wr.I185.MXNA1 SO SAO0 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_wr.I185.MXPA1 SO SAO0 VDDPE VNWP P11LL_CKT W=0.145U L=0.04U
X_M_wr.I186.MXNA1 _WR.ND_LAT0 _WR.D_LAT0 VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I186.MXPA1 _WR.ND_LAT0 _WR.D_LAT0 VDDPE VNWP P11LL_CKT W=0.255U L=0.04U
X_M_wr.I192.MXNA1 _WR.ND_LAT1 _WR.D_LAT1 VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I192.MXPA1 _WR.ND_LAT1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT W=0.255U L=0.04U
X_M_wr.I194.MXNA1 D_WT _WR.ND_LAT1 VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I194.MXPA1 D_WT _WR.ND_LAT1 VDDPE VNWP P11LL_CKT W=0.255U L=0.04U
X_M_wr.I195.MXNA1 _WR.INWCLK _WR.WCLK VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr.I195.MXPA1 _WR.INWCLK _WR.WCLK VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I196.MXNA1 _WR.SI0 SAO1 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_wr.I196.MXPA1 _WR.SI0 SAO1 VDDPE VNWP P11LL_CKT W=0.145U L=0.04U
X_M_wr.IV_WrClk.MXNA1 _WR.WCLK NWCLK VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr.IV_WrClk.MXPA1 _WR.WCLK NWCLK VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr._dlat0.I1_0.MXNA1 _WR._DLAT0.NSEL3 SEL_SI VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I1_0.MXPA1 _WR._DLAT0.NSEL3 SEL_SI VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I1_1.MXNA1 _WR._DLAT0.NSEL2 SEL_TD VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I1_1.MXPA1 _WR._DLAT0.NSEL2 SEL_TD VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I1_2.MXNA1 _WR._DLAT0.NSEL1 SEL_D VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I1_2.MXPA1 _WR._DLAT0.NSEL1 SEL_D VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat0.I50.MXNA1 _WR.D_LAT0 _WR.DLAT_NQ0 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat0.I50.MXPA1 _WR.D_LAT0 _WR.DLAT_NQ0 VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat0.I55.MXNA1 _WR._DLAT0.I55.N1 _WR.D_LAT0 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat0.I55.MXNOE _WR.DLAT_NQ0 _WR.WCLK _WR._DLAT0.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat0.I55.MXPA1 _WR._DLAT0.I55.P1 _WR.D_LAT0 VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat0.I55.MXPOEN _WR.DLAT_NQ0 _WR.INWCLK _WR._DLAT0.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._dlat0.I65.MXNOE _WR.DLAT_NQ0 _WR.INWCLK _WR._DLAT0.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._dlat0.I65.MXPOEN _WR.DLAT_NQ0 _WR.WCLK _WR._DLAT0.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat0.MXN1 _WR._DLAT0.N2 TD0 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat0.MXN2 _WR._DLAT0.N1 D0 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat0.MXN3 _WR._DLAT0.ND SEL_D _WR._DLAT0.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat0.MXN4 _WR._DLAT0.ND SEL_TD _WR._DLAT0.N2 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat0.MXN5 _WR._DLAT0.N3 _WR.SI0 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat0.MXN6 _WR._DLAT0.ND SEL_SI _WR._DLAT0.N3 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat0.MXP0 _WR._DLAT0.ND _WR._DLAT0.NSEL1 _WR._DLAT0.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat0.MXP1 _WR._DLAT0.P1 D0 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat0.MXP2 _WR._DLAT0.ND _WR._DLAT0.NSEL2 _WR._DLAT0.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat0.MXP3 _WR._DLAT0.P2 TD0 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat0.MXP4 _WR._DLAT0.ND _WR._DLAT0.NSEL3 _WR._DLAT0.P3 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat0.MXP5 _WR._DLAT0.P3 _WR.SI0 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat1.I1_0.MXNA1 _WR._DLAT1.NSEL3 SEL_SI VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I1_0.MXPA1 _WR._DLAT1.NSEL3 SEL_SI VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I1_1.MXNA1 _WR._DLAT1.NSEL2 SEL_TD VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I1_1.MXPA1 _WR._DLAT1.NSEL2 SEL_TD VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I1_2.MXNA1 _WR._DLAT1.NSEL1 SEL_D VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I1_2.MXPA1 _WR._DLAT1.NSEL1 SEL_D VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._dlat1.I50.MXNA1 _WR.D_LAT1 _WR.DLAT_NQ1 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat1.I50.MXPA1 _WR.D_LAT1 _WR.DLAT_NQ1 VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat1.I55.MXNA1 _WR._DLAT1.I55.N1 _WR.D_LAT1 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat1.I55.MXNOE _WR.DLAT_NQ1 _WR.WCLK _WR._DLAT1.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat1.I55.MXPA1 _WR._DLAT1.I55.P1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat1.I55.MXPOEN _WR.DLAT_NQ1 _WR.INWCLK _WR._DLAT1.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._dlat1.I65.MXNOE _WR.DLAT_NQ1 _WR.INWCLK _WR._DLAT1.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._dlat1.I65.MXPOEN _WR.DLAT_NQ1 _WR.WCLK _WR._DLAT1.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat1.MXN1 _WR._DLAT1.N2 TD1 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat1.MXN2 _WR._DLAT1.N1 D1 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat1.MXN3 _WR._DLAT1.ND SEL_D _WR._DLAT1.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat1.MXN4 _WR._DLAT1.ND SEL_TD _WR._DLAT1.N2 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat1.MXN5 _WR._DLAT1.N3 SI VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat1.MXN6 _WR._DLAT1.ND SEL_SI _WR._DLAT1.N3 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat1.MXP0 _WR._DLAT1.ND _WR._DLAT1.NSEL1 _WR._DLAT1.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat1.MXP1 _WR._DLAT1.P1 D1 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat1.MXP2 _WR._DLAT1.ND _WR._DLAT1.NSEL2 _WR._DLAT1.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat1.MXP3 _WR._DLAT1.P2 TD1 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat1.MXP4 _WR._DLAT1.ND _WR._DLAT1.NSEL3 _WR._DLAT1.P3 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat1.MXP5 _WR._DLAT1.P3 SI VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._tri0.I169.MXNA1 _WR._TRI0.NET127 _WR.WEN_LAT0 VSS VPW N11LL_CKT
+  W=0.18U L=0.04U
X_M_wr._tri0.I169.MXNA2 _WR._TRI0.NET127 _WR.D_LAT0 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri0.I169.MXPA1 _WR._TRI0.NET127 _WR.WEN_LAT0 _WR._TRI0.I169.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri0.I169.MXPA2 _WR._TRI0.I169.P1 _WR.D_LAT0 VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri0.I179.MXNA1 _WR._TRI0.NET120 _WR.WEN_LAT0 VSS VPW N11LL_CKT
+  W=0.18U L=0.04U
X_M_wr._tri0.I179.MXNA2 _WR._TRI0.NET120 _WR.ND_LAT0 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri0.I179.MXPA1 _WR._TRI0.NET120 _WR.WEN_LAT0 _WR._TRI0.I179.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri0.I179.MXPA2 _WR._TRI0.I179.P1 _WR.ND_LAT0 VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri0.MXN0 WRONE0 _WR._TRI0.NET127 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri0.MXN1 WRZERO0 _WR._TRI0.NET120 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri0.MXP0 _WR._TRI0.HZWRONE _WR.WEN_LAT0 VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri0.MXP1 WRONE0 _WR._TRI0.NET127 _WR._TRI0.HZWRONE VNWP P11LL_CKT
+  W=0.44U L=0.04U
X_M_wr._tri0.MXP11 _WR._TRI0.HZWRONE _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri0.MXP12 _WR._TRI0.HZWRZERO _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri0.MXP2 WRZERO0 _WR._TRI0.NET120 _WR._TRI0.HZWRZERO VNWP P11LL_CKT
+  W=0.44U L=0.04U
X_M_wr._tri0.MXP3 _WR._TRI0.HZWRZERO _WR.WEN_LAT0 VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri1.I169.MXNA1 _WR._TRI1.NET127 _WR.WEN_LAT1 VSS VPW N11LL_CKT
+  W=0.18U L=0.04U
X_M_wr._tri1.I169.MXNA2 _WR._TRI1.NET127 _WR.D_LAT1 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri1.I169.MXPA1 _WR._TRI1.NET127 _WR.WEN_LAT1 _WR._TRI1.I169.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri1.I169.MXPA2 _WR._TRI1.I169.P1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri1.I179.MXNA1 _WR._TRI1.NET120 _WR.WEN_LAT1 VSS VPW N11LL_CKT
+  W=0.18U L=0.04U
X_M_wr._tri1.I179.MXNA2 _WR._TRI1.NET120 _WR.ND_LAT1 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri1.I179.MXPA1 _WR._TRI1.NET120 _WR.WEN_LAT1 _WR._TRI1.I179.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri1.I179.MXPA2 _WR._TRI1.I179.P1 _WR.ND_LAT1 VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri1.MXN0 WRONE1 _WR._TRI1.NET127 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri1.MXN1 WRZERO1 _WR._TRI1.NET120 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri1.MXP0 _WR._TRI1.HZWRONE _WR.WEN_LAT1 VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri1.MXP1 WRONE1 _WR._TRI1.NET127 _WR._TRI1.HZWRONE VNWP P11LL_CKT
+  W=0.44U L=0.04U
X_M_wr._tri1.MXP11 _WR._TRI1.HZWRONE _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri1.MXP12 _WR._TRI1.HZWRZERO _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri1.MXP2 WRZERO1 _WR._TRI1.NET120 _WR._TRI1.HZWRZERO VNWP P11LL_CKT
+  W=0.44U L=0.04U
X_M_wr._tri1.MXP3 _WR._TRI1.HZWRZERO _WR.WEN_LAT1 VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._wenlat0.I0.MXNA1 _WR._WENLAT0.NDY _WR._WENLAT0.IDY _WR._WENLAT0.I0.N1
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr._wenlat0.I0.MXNA2 _WR._WENLAT0.I0.N1 DFTRAMBYP VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenlat0.I0.MXPA1 _WR._WENLAT0.NDY _WR._WENLAT0.IDY VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_wr._wenlat0.I0.MXPA2 _WR._WENLAT0.NDY DFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenlat0.I50.MXNA1 _WR.WEN_LAT0 _WR.WE_LAT0 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._wenlat0.I50.MXPA1 _WR.WEN_LAT0 _WR.WE_LAT0 VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat0.I55.MXNA1 _WR._WENLAT0.I55.N1 _WR.WEN_LAT0 VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenlat0.I55.MXNOE _WR.WE_LAT0 _WR.WCLK _WR._WENLAT0.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat0.I55.MXPA1 _WR._WENLAT0.I55.P1 _WR.WEN_LAT0 VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat0.I55.MXPOEN _WR.WE_LAT0 _WR.INWCLK _WR._WENLAT0.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat0.I57.MXNA1 _WR._WENLAT0.NSEL TE VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenlat0.I57.MXPA1 _WR._WENLAT0.NSEL TE VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenlat0.I62.MXNA1 WENY0 _WR._WENLAT0.NDY VSS VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_wr._wenlat0.I62.MXPA1 WENY0 _WR._WENLAT0.NDY VDDPE VNWP P11LL_CKT W=1.12U
+  L=0.04U
X_M_wr._wenlat0.I63.MXNA1 _WR._WENLAT0.IDY _WR._WENLAT0.ND VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenlat0.I63.MXPA1 _WR._WENLAT0.IDY _WR._WENLAT0.ND VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat0.I65.MXNOE _WR.WE_LAT0 _WR.INWCLK _WR._WENLAT0.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat0.I65.MXPOEN _WR.WE_LAT0 _WR.WCLK _WR._WENLAT0.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat0.MXN1 _WR._WENLAT0.ND TWEN0_PRG _WR._WENLAT0.N2 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat0.MXN2 _WR._WENLAT0.ND WEN0_PRG _WR._WENLAT0.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat0.MXN5 _WR._WENLAT0.N1 _WR._WENLAT0.NSEL VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat0.MXN6 _WR._WENLAT0.N2 TE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._wenlat0.MXP1 _WR._WENLAT0.ND WEN0_PRG _WR._WENLAT0.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat0.MXP3 _WR._WENLAT0.ND TWEN0_PRG _WR._WENLAT0.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat0.MXP4 _WR._WENLAT0.P1 TE VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._wenlat0.MXP5 _WR._WENLAT0.P2 _WR._WENLAT0.NSEL VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat1.I0.MXNA1 _WR._WENLAT1.NDY _WR._WENLAT1.IDY _WR._WENLAT1.I0.N1
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr._wenlat1.I0.MXNA2 _WR._WENLAT1.I0.N1 DFTRAMBYP VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenlat1.I0.MXPA1 _WR._WENLAT1.NDY _WR._WENLAT1.IDY VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_wr._wenlat1.I0.MXPA2 _WR._WENLAT1.NDY DFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenlat1.I50.MXNA1 _WR.WEN_LAT1 _WR.WE_LAT1 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._wenlat1.I50.MXPA1 _WR.WEN_LAT1 _WR.WE_LAT1 VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat1.I55.MXNA1 _WR._WENLAT1.I55.N1 _WR.WEN_LAT1 VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenlat1.I55.MXNOE _WR.WE_LAT1 _WR.WCLK _WR._WENLAT1.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat1.I55.MXPA1 _WR._WENLAT1.I55.P1 _WR.WEN_LAT1 VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat1.I55.MXPOEN _WR.WE_LAT1 _WR.INWCLK _WR._WENLAT1.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat1.I57.MXNA1 _WR._WENLAT1.NSEL TE VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenlat1.I57.MXPA1 _WR._WENLAT1.NSEL TE VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenlat1.I62.MXNA1 WENY1 _WR._WENLAT1.NDY VSS VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_wr._wenlat1.I62.MXPA1 WENY1 _WR._WENLAT1.NDY VDDPE VNWP P11LL_CKT W=1.12U
+  L=0.04U
X_M_wr._wenlat1.I63.MXNA1 _WR._WENLAT1.IDY _WR._WENLAT1.ND VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenlat1.I63.MXPA1 _WR._WENLAT1.IDY _WR._WENLAT1.ND VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenlat1.I65.MXNOE _WR.WE_LAT1 _WR.INWCLK _WR._WENLAT1.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat1.I65.MXPOEN _WR.WE_LAT1 _WR.WCLK _WR._WENLAT1.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat1.MXN1 _WR._WENLAT1.ND TWEN1_PRG _WR._WENLAT1.N2 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat1.MXN2 _WR._WENLAT1.ND WEN1_PRG _WR._WENLAT1.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat1.MXN5 _WR._WENLAT1.N1 _WR._WENLAT1.NSEL VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenlat1.MXN6 _WR._WENLAT1.N2 TE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._wenlat1.MXP1 _WR._WENLAT1.ND WEN1_PRG _WR._WENLAT1.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat1.MXP3 _WR._WENLAT1.ND TWEN1_PRG _WR._WENLAT1.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenlat1.MXP4 _WR._WENLAT1.P1 TE VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._wenlat1.MXP5 _WR._WENLAT1.P2 _WR._WENLAT1.NSEL VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
.ENDS RAMSP128X16COLM2X2_BIST_WM
****
.SUBCKT RAMSP128X16IOCDM_L BL0_0 BL0_1 BL0_2 BL0_3 BL1_0 BL1_1 BL1_2 BL1_3
+  BL2_0 BL2_1 BL2_2 BL2_3 BL3_0 BL3_1 BL3_2 BL3_3 BLPRECH D0_0 D0_1 D0_2 D0_3
+  D1_0 D1_1 D1_2 D1_3 DFTRAMBYP DUM_NWCLK_L DUM_NWCLK_R DUM_SEL_D_L
+  DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L DUM_SEL_TD_R DWL LOG0
+  NACT_CC NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL2_0
+  NBL2_1 NBL2_2 NBL2_3 NBL3_0 NBL3_1 NBL3_2 NBL3_3 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAPRECH SEL_D
+  SEL_SI SEL_TD SI SO TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE
+  TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENL TWENR
+  VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VPW
+  WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENL WENR WENY0_0
+  WENY0_1 WENY0_2 WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1
** RAMSP128X16IOCDM_L: 1060 flat devices **
XL_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D0_1 D1_1 DFTRAMBYP DUM_NWCLK_R_0
+  DUM_NWCLK_R_28 DUM_SEL_D_R_2 DUM_SEL_D_R_30 DUM_SEL_SI_R_4 DUM_SEL_SI_R_32
+  DUM_SEL_TD_R_6 DUM_SEL_TD_R_34 DWL LOG0 NACT_CC NBL0_1 NBL1_1 NBL2_1 NBL3_1
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_1 SAO1_1 SAPRECH SEL_D SEL_SI SEL_TD
+  SO_8 SO_36 TD0_1 TD1_1 TE TWEN0_1 TWEN0_1 TWEN1_1 TWEN1_1 TWENR_10 TWENR_38
+  VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW WEN0_1 WEN0_1 WEN1_1 WEN1_1
+  WENR_12 WENR_40 WENY0_1 WENY1_1 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
XL_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D0_2 D1_2 DFTRAMBYP DUM_NWCLK_R_28
+  DUM_NWCLK_L_14 DUM_SEL_D_R_30 DUM_SEL_D_L_16 DUM_SEL_SI_R_32
+  DUM_SEL_SI_L_18 DUM_SEL_TD_R_34 DUM_SEL_TD_L_20 DWL LOG0 NACT_CC NBL0_2
+  NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_2 SAO1_2 SAPRECH
+  SEL_D SEL_SI SEL_TD SO_36 SI_22 TD0_2 TD1_2 TE TWEN0_2 TWEN0_2 TWEN1_2
+  TWEN1_2 TWENR_38 TWENL_24 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW
+  WEN0_2 WEN0_2 WEN1_2 WEN1_2 WENR_40 WENL_26 WENY0_2 WENY1_2 YW0 YW1
+  RAMSP128X16COLM2X2_BIST_WM
XL_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D0_0 D1_0 DFTRAMBYP DUM_NWCLK_L
+  DUM_NWCLK_R_0 DUM_SEL_D_L DUM_SEL_D_R_2 DUM_SEL_SI_L DUM_SEL_SI_R_4
+  DUM_SEL_TD_L DUM_SEL_TD_R_6 DWL LOG0 NACT_CC NBL0_0 NBL1_0 NBL2_0 NBL3_0
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_0 SAO1_0 SAPRECH SEL_D SEL_SI SEL_TD SI
+  SO_8 TD0_0 TD1_0 TE TWEN0_0 TWEN0_0 TWEN1_0 TWEN1_0 TWENL TWENR_10 VDDC_0
+  VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW WEN0_0 WEN0_0 WEN1_0 WEN1_0 WENL
+  WENR_12 WENY0_0 WENY1_0 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
XL_IO_R BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D0_3 D1_3 DFTRAMBYP DUM_NWCLK_L_14
+  DUM_NWCLK_R DUM_SEL_D_L_16 DUM_SEL_D_R DUM_SEL_SI_L_18 DUM_SEL_SI_R
+  DUM_SEL_TD_L_20 DUM_SEL_TD_R DWL LOG0 NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_3 SAO1_3 SAPRECH SEL_D SEL_SI SEL_TD
+  SI_22 SO TD0_3 TD1_3 TE TWEN0_3 TWEN0_3 TWEN1_3 TWEN1_3 TWENL_24 TWENR
+  VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW WEN0_3 WEN0_3 WEN1_3 WEN1_3
+  WENL_26 WENR WENY0_3 WENY1_3 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
.ENDS RAMSP128X16IOCDM_L
****
.SUBCKT RAMSP128X16FLCOLM2_BIST_WM BLPRECH DFTRAMBYP DUM_NWCLK DUM_SEL_D
+  DUM_SEL_SI DUM_SEL_TD DWL LOG0 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1
+  SAPRECH SEL_D SEL_SI SEL_TD SI TE TWEN VDDCE VDDPE VNWC VNWP VPW VSS VSSE
+  WEN YW0 YW1
** RAMSP128X16FLCOLM2_BIST_WM: 2 flat devices **
X_MXN0 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN3 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
.ENDS RAMSP128X16FLCOLM2_BIST_WM
****
.SUBCKT RAMSP128X16CCHD4_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP128X16CCHD4_CORNER: 3 flat devices **
X_MXN0 VSSE NET17 NET16 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET21 NET20 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET25 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP128X16CCHD4_CORNER
****
.SUBCKT RAMSP128X16IOEDGE BLPRECH DFTRAMBYP DUM_NWCLK DUM_SEL_D_0 DUM_SEL_D_1
+  DUM_SEL_SI DUM_SEL_TD_0 DUM_SEL_TD_1 DWL LOG0 NACT_CC NSAE NWCLK NWCLK_WT
+  NYR0 NYR1 SAPRECH SEL_D SEL_SI SEL_TD SI TE TWEN VDDC VDDCE VDDPE VNWC VPW
+  VSS WEN YW0 YW1
** RAMSP128X16IOEDGE: 5 flat devices **
XCOLM_EDGE BLPRECH DFTRAMBYP DUM_NWCLK DUM_SEL_D_1 DUM_SEL_SI DUM_SEL_TD_1 DWL
+  LOG0 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1 SAPRECH SEL_D SEL_SI SEL_TD SI
+  TE TWEN VDDCE VDDPE VNWC VDDPE VPW VSS VPW WEN YW0 YW1
+  RAMSP128X16FLCOLM2_BIST_WM
XIO_CORNER VDDC VNWC VDDPE VPW VPW RAMSP128X16CCHD4_CORNER
.ENDS RAMSP128X16IOEDGE
****
.SUBCKT RAMSP128X16RDM2X2 D0 D1 DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L
+  DUM_SEL_TD_R Q0 Q1 SAO0 SAO1 TD0 TD1 TWEN0 TWEN1 VDDCE VDDPE VNWP VPW VSS
+  VSSE WEN0 WEN1 WENY0 WENY1
** RAMSP128X16RDM2X2: 4 flat devices **
X_M_rd0.I149.MXNA1 Q0 SAO0 VSS VPW N11LL_CKT W=2.04U L=0.04U
X_M_rd0.I149.MXPA1 Q0 SAO0 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
X_M_rd1.I149.MXNA1 Q1 SAO1 VSS VPW N11LL_CKT W=2.04U L=0.04U
X_M_rd1.I149.MXPA1 Q1 SAO1 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
.ENDS RAMSP128X16RDM2X2
****
.SUBCKT RAMSP128X16IO_RDM_L D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q1_0
+  Q1_1 Q1_2 Q1_3 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3
+  TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VPW_0 VPW_1
+  VPW_2 VPW_3 VSS_0 VSS_1 VSS_2 VSS_3 WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3
** RAMSP128X16IO_RDM_L: 16 flat devices **
XL_RDM_1 D0_1 D1_1 DUM_SEL_D_R_0 DUM_SEL_D_R_4 DUM_SEL_TD_R_2 DUM_SEL_TD_R_6
+  Q0_1 Q1_1 SAO0_1 SAO1_1 TD0_1 TD1_1 TWEN0_1 TWEN1_1 VDDCE_1 VDDPE_1 VNWP_1
+  VPW_1 VSS_1 VSS_1 WEN0_1 WEN1_1 WENY0_1 WENY1_1 RAMSP128X16RDM2X2
XL_RDM_2 D0_2 D1_2 DUM_SEL_D_R_4 DUM_SEL_D_L_8 DUM_SEL_TD_R_6 DUM_SEL_TD_L_10
+  Q0_2 Q1_2 SAO0_2 SAO1_2 TD0_2 TD1_2 TWEN0_2 TWEN1_2 VDDCE_2 VDDPE_2 VNWP_2
+  VPW_2 VSS_2 VSS_2 WEN0_2 WEN1_2 WENY0_2 WENY1_2 RAMSP128X16RDM2X2
XL_RDM_L D0_0 D1_0 DUM_SEL_D_L DUM_SEL_D_R_0 DUM_SEL_TD_L DUM_SEL_TD_R_2 Q0_0
+  Q1_0 SAO0_0 SAO1_0 TD0_0 TD1_0 TWEN0_0 TWEN1_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0
+  VSS_0 VSS_0 WEN0_0 WEN1_0 WENY0_0 WENY1_0 RAMSP128X16RDM2X2
XL_RDM_R D0_3 D1_3 DUM_SEL_D_L_8 DUM_SEL_D_R DUM_SEL_TD_L_10 DUM_SEL_TD_R Q0_3
+  Q1_3 SAO0_3 SAO1_3 TD0_3 TD1_3 TWEN0_3 TWEN1_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3
+  VSS_3 VSS_3 WEN0_3 WEN1_3 WENY0_3 WENY1_3 RAMSP128X16RDM2X2
.ENDS RAMSP128X16IO_RDM_L
****
.SUBCKT RAMSP128X16CCHD4_TOPBOT BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** RAMSP128X16CCHD4_TOPBOT: 32 flat devices **
X_MXN16 VSSE NET150 NET93 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN17 NBL[2] VPW NET97 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN18 NET88 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN19 VPW VPW NET45 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN20 NET80 NET154 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN21 VPW NET146 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN22 VPW NET114 NET61 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN23 VPW NET158 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN24 NET84 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN25 VPW NET142 NET57 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN26 VPW NET138 NET49 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN27 NET64 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN28 VPW NET130 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN29 VPW NET126 NET37 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN30 VPW NET134 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN31 NET32 NET118 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN32 VPW VPW NET41 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN33 NET104 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN34 NBL[0] VPW NET101 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN35 VSSE NET122 NET73 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET149 NET150 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 VDDC NET154 NET151 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 VNWC NET158 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 NET113 NET114 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET141 NET142 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 VNWC NET146 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP20 VNWC NET134 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP21 NET137 NET138 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP22 NET125 NET126 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP23 VNWC NET130 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP24 VDDC NET118 NET115 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP25 NET121 NET122 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMSP128X16CCHD4_TOPBOT
****
.SUBCKT RAMSP128X16IOTOPCAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VPW
** RAMSP128X16IOTOPCAP_L: 128 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
.ENDS RAMSP128X16IOTOPCAP_L
****
.SUBCKT RAMSP128X16IO_ROW_L BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DFTRAMBYP
+  DUM_NWCLK_R DUM_SEL_D_R_0 DUM_SEL_D_R_1 DUM_SEL_SI_R DUM_SEL_TD_R_0
+  DUM_SEL_TD_R_1 DWL LOG0_0 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NSAE NWCLK NWCLK_WT NYR0 NYR1
+  Q0_0 Q0_1 Q0_2 Q0_3 Q1_0 Q1_1 Q1_2 Q1_3 SAPRECH SEL_D SEL_SI SEL_TD SO
+  TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENR VDDCE VDDPE VPW WEN0_0 WEN0_1
+  WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENR WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1
** RAMSP128X16IO_ROW_L: 1209 flat devices **
XIO_CDM_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BLPRECH
+  D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DFTRAMBYP DUM_NWCLK_L DUM_NWCLK_R
+  DUM_SEL_D_L DUM_SEL_D_R_1 DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L
+  DUM_SEL_TD_R_1 DWL LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_0
+  SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAPRECH SEL_D SEL_SI
+  SEL_TD LOG0_0 SO TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE TWEN0_0
+  TWEN0_1 TWEN0_2 TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENL TWENR VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDPE VDDCE VDDCE VDDCE VDDCE VPW WEN0_0 WEN0_1
+  WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENL WENR WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1 RAMSP128X16IOCDM_L
XIO_EDGE_L BLPRECH DFTRAMBYP DUM_NWCLK_L DUM_SEL_D_0 DUM_SEL_D_L DUM_SEL_SI_L
+  DUM_SEL_TD_0 DUM_SEL_TD_L DWL LOG0_1 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1
+  SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL VDDCE VDDCE VDDPE VDDCE VPW VPW
+  WENL YW0 YW1 RAMSP128X16IOEDGE
XIO_RDM_ROW_L D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DUM_SEL_D_0
+  DUM_SEL_D_R_0 DUM_SEL_TD_0 DUM_SEL_TD_R_0 Q0_0 Q0_1 Q0_2 Q0_3 Q1_0 Q1_1
+  Q1_2 Q1_3 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 TD0_0
+  TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3
+  TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 VDDCE VDDCE VDDCE VDDCE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW WEN0_0 WEN0_1
+  WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENY0_0 WENY0_1 WENY0_2 WENY0_3
+  WENY1_0 WENY1_1 WENY1_2 WENY1_3 RAMSP128X16IO_RDM_L
XIO_TOPCAP_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDCE VDDPE VDDPE VDDPE VDDPE VPW RAMSP128X16IOTOPCAP_L
.ENDS RAMSP128X16IO_ROW_L
****
.SUBCKT RAMSP128X16CKM2_BIST ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1
+  CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAMBYP DFTRAM_RET DUMMY_DWL_BOT DUM_PEN
+  DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL EMAW[0] EMAW[1] EMA[0]
+  EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP
+  IRA_P2[5] LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_WT
+  NYR0 NYR1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0]
+  RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RDT RET RET1N SAE_DUMMY
+  SAPRECH SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TE TEN TGWEN
+  TLA0 TLA1 TLA2 TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE VDDC_L VDDC_LEFT VDDC_R
+  VDDC_RIGHT VDDP VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE WR_THRU YW0 YW1
** RAMSP128X16CKM2_BIST: 711 flat devices **
X_MI0.MXNA1 NET0564 RET1N I0.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXNA2 I0.N1 WEMA00_N VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXPA1 NET0564 RET1N VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI0.MXPA2 NET0564 WEMA00_N VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI1.MXNA1 IWCLK_WT INWCLK_WT I1.N1 VPW N11LL_CKT W=1U L=0.04U
X_MI1.MXNA2 I1.N1 NET0694 VSS VPW N11LL_CKT W=1U L=0.04U
X_MI1.MXPA1 IWCLK_WT INWCLK_WT VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MI1.MXPA2 IWCLK_WT NET0694 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MI102.MXNA1 NTE TE VSS VPW N11LL_CKT W=1.855U L=0.04U
X_MI102.MXPA1 NTE TE VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MI107.I2.MXNA1 SEL_SI I107.NSE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I2.MXPA1 SEL_SI I107.NSE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I4.MXNA1 SEL_TD I107.NET18 VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I4.MXPA1 SEL_TD I107.NET18 VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I5.MXNA1 SEL_D I107.TE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I5.MXPA1 SEL_D I107.TE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I7.MXNA1 I107.NSE SE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI107.I7.MXPA1 I107.NSE SE VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI107.I8.MXNA1 I107.NET18 I107.NSE I107.I8.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXNA2 I107.I8.N1 I107.TE VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA1 I107.NET18 I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA2 I107.NET18 I107.TE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA1 I107.TE I107.NSE I107.I83.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA2 I107.I83.N1 TEN VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA1 I107.TE I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA2 I107.TE TEN VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI115.MXNA1 NRDT_RD GWEN_P2 I115.N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA2 I115.N2 RET1N I115.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA3 I115.N1 RDT_P2 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXPA1 NRDT_RD GWEN_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA2 NRDT_RD RET1N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA3 NRDT_RD RDT_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI116_0.MXNA1 SO0 NSO0 VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI116_0.MXPA1 SO0 NSO0 VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MI116_1.MXNA1 SO1 NSO1 VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI116_1.MXPA1 SO1 NSO1 VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MI117.MXNA1 IDFTRAMBYP NDFTRAMBYP VSS VPW N11LL_CKT W=1.065U L=0.04U
X_MI117.MXPA1 IDFTRAMBYP NDFTRAMBYP VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MI118.MXNA1 NDFTRAMBYP DFTRAMBYP VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI118.MXPA1 NDFTRAMBYP DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI12.MXNA1 NDY CEN_P2 I12.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXNA2 I12.N1 IDFTRAMBYP VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA1 NDY CEN_P2 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA2 NDY IDFTRAMBYP VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI120.MXNA1 RDT_RD NRDT_RD VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_MI120.MXPA1 RDT_RD NRDT_RD VDDPE VNWP P11LL_CKT W=0.79U L=0.04U
X_MI121_0.MXNA1 NSO0 NSAO_L VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI121_0.MXPA1 NSO0 NSAO_L VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI121_1.MXNA1 NSO1 NSAO_R VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI121_1.MXPA1 NSO1 NSAO_R VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI123.MXNA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI123.MXPA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MI125.MXNA1 I125.N1 CA_P2[0] VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI125.MXNOE NET0623 CA_P2[0] I125.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_MI125.MXPA1 I125.P1 CA_P2[0] VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI125.MXPOEN NET0623 CA_P2[0] I125.P1 VNWP P11LL_CKT W=0.565U L=0.04U
X_MI126.MXNA1 CADDR0 NET0623 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI126.MXPA1 CADDR0 NET0623 VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI127.MXNA1 NCADDR0 CADDR0 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI127.MXPA1 NCADDR0 CADDR0 VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI131.MXN0 VSSE I131.NET19 I131.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI131.MXN2 VPW I131.NET15 I131.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI131.MXN3 VPW I131.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI134.MXNA1 NET0569 RET1N I134.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXNA2 I134.N1 NDFTRAMBYP_LAT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA1 NET0569 RET1N VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA2 NET0569 NDFTRAMBYP_LAT VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI135.MXNA1 DFTRAM_NRET NET0569 VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI135.MXPA1 DFTRAM_NRET NET0569 VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI138.MXNA1 RET RET1N VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI138.MXPA1 RET RET1N VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI146.MXNA1 NCLK_GTPSA BCLK_GTPSA VSS VPW N11LL_CKT W=0.2U L=0.04U
X_MI146.MXPA1 NCLK_GTPSA BCLK_GTPSA VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI147.MXNA1 NET0673 DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI147.MXPA1 NET0673 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI148.MXNA1 ISAPRECH GTP VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI148.MXNA2 ISAPRECH GTPSA_SPLIT VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI148.MXPA1 ISAPRECH GTP I148.P1 VNWP P11LL_CKT W=0.855U L=0.04U
X_MI148.MXPA2 I148.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI150.MXNA1 IDFTRAMBYP_LAT NET0673 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI150.MXPA1 IDFTRAMBYP_LAT NET0673 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI151.MXNA1 NET0680 INSAE VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI151.MXPA1 NET0680 INSAE VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI152.MXNA1 INSAE_DLY NET0680 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI152.MXPA1 INSAE_DLY NET0680 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI1521.MXNA1 CEN_P2 NET0176 VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MI1521.MXPA1 CEN_P2 NET0176 VDDPE VNWP P11LL_CKT W=1.28U L=0.04U
X_MI154.MXNA1 NET0700 INWCLK_WT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI154.MXPA1 NET0700 INWCLK_WT VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI155.MXNA1 NET0694 NET0700 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI155.MXPA1 NET0694 NET0700 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI156.MXN0 I156.NET44 I156.NET32 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN1 I156.NET40 DWL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN2 I156.NET36 I156.NET40 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN3 VSS I156.NET44 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN4 I156.NET32 I156.NET40 I156.NET36 VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN8 DWL_DLY I156.NET44 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXP0 DWL_DLY I156.NET44 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP1 I156.NET23 I156.NET32 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP2 I156.NET44 I156.NET32 I156.NET23 VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP4 I156.NET40 DWL VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_MI156.MXP5 I156.NET32 I156.NET40 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI157.MXNA1 WEMA00 EMAW[0] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI157.MXNA2 WEMA00 EMAW[1] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI157.MXPA1 WEMA00 EMAW[0] I157.P1 VNWP P11LL_CKT W=0.17U L=0.04U
X_MI157.MXPA2 I157.P1 EMAW[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI158.MXNA1 WEMA00_N WEMA00 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI158.MXPA1 WEMA00_N WEMA00 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI159.MXNA1 RET1N_WEMA00N NET0564 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI159.MXPA1 RET1N_WEMA00N NET0564 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI169.MXNA1 NET0551 GTP VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI169.MXNA2 NET0551 GTPSA_SPLIT VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI169.MXPA1 NET0551 GTP I169.P1 VNWP P11LL_CKT W=0.6U L=0.04U
X_MI169.MXPA2 I169.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI2.MXNA1 BCLK_GTPSA NET0551 I2.N1 VPW N11LL_CKT W=0.6U L=0.04U
X_MI2.MXNA2 I2.N1 WRITE_NGTP VSS VPW N11LL_CKT W=0.6U L=0.04U
X_MI2.MXPA1 BCLK_GTPSA NET0551 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI2.MXPA2 BCLK_GTPSA WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI32.MXNA1 NCLK GTP VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI32.MXPA1 NCLK GTP VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI4.MXNA1 NICLK GTP VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI4.MXPA1 NICLK GTP VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MI5.MXNA1 BCLK NICLK VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI5.MXPA1 BCLK NICLK VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI51.MXNA1 NGTP GTP VSS VPW N11LL_CKT W=0.855U L=0.04U
X_MI51.MXPA1 NGTP GTP VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_MI52.MXNA1 DFTRAM_RET DFTRAM_NRET VSSE VPW N11LL_CKT W=3.55U L=0.04U
X_MI52.MXPA1 DFTRAM_RET DFTRAM_NRET VDDCE VNWC P11LL_CKT W=7.1U L=0.04U
X_MI62.MXNA1 CENY NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI62.MXPA1 CENY NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MI63.MXNA1 NGWE_DFT GWE_P2 VSS VPW N11LL_CKT W=0.44U L=0.04U
X_MI63.MXNA2 NGWE_DFT IDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.44U L=0.04U
X_MI63.MXPA1 NGWE_DFT GWE_P2 I63.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_MI63.MXPA2 I63.P1 IDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI64.MXNA1 NSAPRECH ISAPRECH VSS VPW N11LL_CKT W=1.425U L=0.04U
X_MI64.MXPA1 NSAPRECH ISAPRECH VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI81.MXNA1 INSAE GTPSA_SPLIT I81.N1 VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXNA2 I81.N1 NGWE_DFT VSS VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXPA1 INSAE GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.515U L=0.04U
X_MI81.MXPA2 INSAE NGWE_DFT VDDPE VNWP P11LL_CKT W=0.515U L=0.04U
X_MI84.MXNA1 NWCLK_WT IWCLK_WT VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MI84.MXPA1 NWCLK_WT IWCLK_WT VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MI91.MXN0 VSSE I91.NET19 I91.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN2 VPW I91.NET15 I91.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN3 VPW I91.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI97.MXNA1 TE TEN VSS VPW N11LL_CKT W=1.96U L=0.04U
X_MI97.MXPA1 TE TEN VDDPE VNWP P11LL_CKT W=3.99U L=0.04U
X_MIV_ALat.MXNA1 GWEN_P2 GWE_P2 VSS VPW N11LL_CKT W=0.59U L=0.04U
X_MIV_ALat.MXPA1 GWEN_P2 GWE_P2 VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MIV_nALat.MXNA1 GWE_P2 GWEN_LAT_Q VSS VPW N11LL_CKT W=0.75U L=0.04U
X_MIV_nALat.MXPA1 GWE_P2 GWEN_LAT_Q VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MXN0 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN1 NET0176 TCEN N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN18 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN19 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
X_MXN2 NET0176 CEN N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN3 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
X_MXN4 NSAE SAE VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN5 N1 NTE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN6 N2 TE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN7 SAE INSAE NET0469 VPW N11LL_CKT W=1.42U L=0.04U
X_MXN8 SAPRECH NSAPRECH VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MXN9 NET0469 INSAE_DLY VSS VPW N11LL_CKT W=1.42U L=0.04U
X_MXP0 NSAE SAE VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_MXP1 NET0176 CEN P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP2 SAE INSAE_DLY VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MXP3 NET0176 TCEN P2 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP4 P1 TE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP5 P2 NTE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP6 SAE INSAE VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MXP7 SAPRECH NSAPRECH VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY _ADDR_LAT_0._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA2 _ADDR_LAT_0._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA2 _ADDR_LAT_0._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXNA1 CA_P2[0] NCA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXPA1 CA_P2[0] NCA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNA1 _ADDR_LAT_0._ADDR_LAT.I55.N1 CA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNOE NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPA1 _ADDR_LAT_0._ADDR_LAT.I55.P1 CA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPOEN NCA_P2[0] NCLK
+  _ADDR_LAT_0._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXNA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXPA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXNA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXPA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXNOE NCA_P2[0] NCLK _ADDR_LAT_0._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXPOEN NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.MXN1 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN2 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN5 _ADDR_LAT_0._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN6 _ADDR_LAT_0._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXP1 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP3 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP4 _ADDR_LAT_0._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP5 _ADDR_LAT_0._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY _ADDR_LAT_1._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA2 _ADDR_LAT_1._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA2 _ADDR_LAT_1._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXNA1 LA_P2[0] NLA_PA[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXPA1 LA_P2[0] NLA_PA[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNA1 _ADDR_LAT_1._ADDR_LAT.I55.N1 LA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNOE NLA_PA[0] BCLK _ADDR_LAT_1._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPA1 _ADDR_LAT_1._ADDR_LAT.I55.P1 LA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPOEN NLA_PA[0] NCLK
+  _ADDR_LAT_1._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXNA1 LAY0 _ADDR_LAT_1._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXPA1 LAY0 _ADDR_LAT_1._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXNA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXPA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXNOE NLA_PA[0] NCLK _ADDR_LAT_1._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXPOEN NLA_PA[0] BCLK _ADDR_LAT_1._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.MXN1 _ADDR_LAT_1._ADDR_LAT.ND TLA0
+  _ADDR_LAT_1._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN2 _ADDR_LAT_1._ADDR_LAT.ND LA0
+  _ADDR_LAT_1._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN5 _ADDR_LAT_1._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN6 _ADDR_LAT_1._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXP1 _ADDR_LAT_1._ADDR_LAT.ND LA0
+  _ADDR_LAT_1._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP3 _ADDR_LAT_1._ADDR_LAT.ND TLA0
+  _ADDR_LAT_1._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP4 _ADDR_LAT_1._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP5 _ADDR_LAT_1._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY _ADDR_LAT_2._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA2 _ADDR_LAT_2._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA2 _ADDR_LAT_2._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXNA1 RA_P2[0] NRA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXPA1 RA_P2[0] NRA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNA1 _ADDR_LAT_2._ADDR_LAT.I55.N1 RA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNOE NRA_P2[0] BCLK _ADDR_LAT_2._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPA1 _ADDR_LAT_2._ADDR_LAT.I55.P1 RA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPOEN NRA_P2[0] NCLK
+  _ADDR_LAT_2._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXNA1 RAY0 _ADDR_LAT_2._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXPA1 RAY0 _ADDR_LAT_2._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXNA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXPA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXNOE NRA_P2[0] NCLK _ADDR_LAT_2._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXPOEN NRA_P2[0] BCLK _ADDR_LAT_2._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.MXN1 _ADDR_LAT_2._ADDR_LAT.ND TRA0
+  _ADDR_LAT_2._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN2 _ADDR_LAT_2._ADDR_LAT.ND RA0
+  _ADDR_LAT_2._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN5 _ADDR_LAT_2._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN6 _ADDR_LAT_2._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXP1 _ADDR_LAT_2._ADDR_LAT.ND RA0
+  _ADDR_LAT_2._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP3 _ADDR_LAT_2._ADDR_LAT.ND TRA0
+  _ADDR_LAT_2._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP4 _ADDR_LAT_2._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP5 _ADDR_LAT_2._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXNA1 _ADDR_LAT_3._ADDR_LAT.NDY
+  _ADDR_LAT_3._ADDR_LAT.IDY _ADDR_LAT_3._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXNA2 _ADDR_LAT_3._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXPA1 _ADDR_LAT_3._ADDR_LAT.NDY
+  _ADDR_LAT_3._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXPA2 _ADDR_LAT_3._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I50.MXNA1 RA_P2[1] NRA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_3._addr_lat.I50.MXPA1 RA_P2[1] NRA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXNA1 _ADDR_LAT_3._ADDR_LAT.I55.N1 RA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXNOE NRA_P2[1] BCLK _ADDR_LAT_3._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXPA1 _ADDR_LAT_3._ADDR_LAT.I55.P1 RA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXPOEN NRA_P2[1] NCLK
+  _ADDR_LAT_3._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I62.MXNA1 RAY1 _ADDR_LAT_3._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_3._addr_lat.I62.MXPA1 RAY1 _ADDR_LAT_3._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_3._addr_lat.I63.MXNA1 _ADDR_LAT_3._ADDR_LAT.IDY
+  _ADDR_LAT_3._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I63.MXPA1 _ADDR_LAT_3._ADDR_LAT.IDY
+  _ADDR_LAT_3._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I65.MXNOE NRA_P2[1] NCLK _ADDR_LAT_3._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_3._addr_lat.I65.MXPOEN NRA_P2[1] BCLK _ADDR_LAT_3._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_3._addr_lat.MXN1 _ADDR_LAT_3._ADDR_LAT.ND TRA1
+  _ADDR_LAT_3._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN2 _ADDR_LAT_3._ADDR_LAT.ND RA1
+  _ADDR_LAT_3._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN5 _ADDR_LAT_3._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN6 _ADDR_LAT_3._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXP1 _ADDR_LAT_3._ADDR_LAT.ND RA1
+  _ADDR_LAT_3._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP3 _ADDR_LAT_3._ADDR_LAT.ND TRA1
+  _ADDR_LAT_3._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP4 _ADDR_LAT_3._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP5 _ADDR_LAT_3._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY _ADDR_LAT_4._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA2 _ADDR_LAT_4._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA2 _ADDR_LAT_4._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXNA1 RA_P2[2] NRA_P2[2] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXPA1 RA_P2[2] NRA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNA1 _ADDR_LAT_4._ADDR_LAT.I55.N1 RA_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNOE NRA_P2[2] BCLK _ADDR_LAT_4._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPA1 _ADDR_LAT_4._ADDR_LAT.I55.P1 RA_P2[2] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPOEN NRA_P2[2] NCLK
+  _ADDR_LAT_4._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXNA1 RAY2 _ADDR_LAT_4._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXPA1 RAY2 _ADDR_LAT_4._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXNA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXPA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXNOE NRA_P2[2] NCLK _ADDR_LAT_4._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXPOEN NRA_P2[2] BCLK _ADDR_LAT_4._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.MXN1 _ADDR_LAT_4._ADDR_LAT.ND TRA2
+  _ADDR_LAT_4._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN2 _ADDR_LAT_4._ADDR_LAT.ND RA2
+  _ADDR_LAT_4._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN5 _ADDR_LAT_4._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN6 _ADDR_LAT_4._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXP1 _ADDR_LAT_4._ADDR_LAT.ND RA2
+  _ADDR_LAT_4._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP3 _ADDR_LAT_4._ADDR_LAT.ND TRA2
+  _ADDR_LAT_4._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP4 _ADDR_LAT_4._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP5 _ADDR_LAT_4._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY _ADDR_LAT_5._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA2 _ADDR_LAT_5._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA2 _ADDR_LAT_5._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXNA1 RA_P2[3] NRA_P2[3] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXPA1 RA_P2[3] NRA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNA1 _ADDR_LAT_5._ADDR_LAT.I55.N1 RA_P2[3] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNOE NRA_P2[3] BCLK _ADDR_LAT_5._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPA1 _ADDR_LAT_5._ADDR_LAT.I55.P1 RA_P2[3] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPOEN NRA_P2[3] NCLK
+  _ADDR_LAT_5._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXNA1 RAY3 _ADDR_LAT_5._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXPA1 RAY3 _ADDR_LAT_5._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXNA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXPA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXNOE NRA_P2[3] NCLK _ADDR_LAT_5._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXPOEN NRA_P2[3] BCLK _ADDR_LAT_5._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.MXN1 _ADDR_LAT_5._ADDR_LAT.ND TRA3
+  _ADDR_LAT_5._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN2 _ADDR_LAT_5._ADDR_LAT.ND RA3
+  _ADDR_LAT_5._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN5 _ADDR_LAT_5._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN6 _ADDR_LAT_5._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXP1 _ADDR_LAT_5._ADDR_LAT.ND RA3
+  _ADDR_LAT_5._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP3 _ADDR_LAT_5._ADDR_LAT.ND TRA3
+  _ADDR_LAT_5._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP4 _ADDR_LAT_5._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP5 _ADDR_LAT_5._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY _ADDR_LAT_6._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA2 _ADDR_LAT_6._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA2 _ADDR_LAT_6._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXNA1 RA_P2[4] NRA_P2[4] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXPA1 RA_P2[4] NRA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNA1 _ADDR_LAT_6._ADDR_LAT.I55.N1 RA_P2[4] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNOE NRA_P2[4] BCLK _ADDR_LAT_6._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPA1 _ADDR_LAT_6._ADDR_LAT.I55.P1 RA_P2[4] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPOEN NRA_P2[4] NCLK
+  _ADDR_LAT_6._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXNA1 RAY4 _ADDR_LAT_6._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXPA1 RAY4 _ADDR_LAT_6._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXNA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXPA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXNOE NRA_P2[4] NCLK _ADDR_LAT_6._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXPOEN NRA_P2[4] BCLK _ADDR_LAT_6._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.MXN1 _ADDR_LAT_6._ADDR_LAT.ND TRA4
+  _ADDR_LAT_6._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN2 _ADDR_LAT_6._ADDR_LAT.ND RA4
+  _ADDR_LAT_6._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN5 _ADDR_LAT_6._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN6 _ADDR_LAT_6._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXP1 _ADDR_LAT_6._ADDR_LAT.ND RA4
+  _ADDR_LAT_6._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP3 _ADDR_LAT_6._ADDR_LAT.ND TRA4
+  _ADDR_LAT_6._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP4 _ADDR_LAT_6._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP5 _ADDR_LAT_6._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY _ADDR_LAT_7._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA2 _ADDR_LAT_7._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA2 _ADDR_LAT_7._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXNA1 IRA_P2[5] NRA_P2[5] VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXPA1 IRA_P2[5] NRA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNA1 _ADDR_LAT_7._ADDR_LAT.I55.N1 IRA_P2[5] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNOE NRA_P2[5] BCLK _ADDR_LAT_7._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPA1 _ADDR_LAT_7._ADDR_LAT.I55.P1 IRA_P2[5]
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPOEN NRA_P2[5] NCLK
+  _ADDR_LAT_7._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXNA1 RAY5 _ADDR_LAT_7._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXPA1 RAY5 _ADDR_LAT_7._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXNA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXPA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXNOE NRA_P2[5] NCLK _ADDR_LAT_7._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXPOEN NRA_P2[5] BCLK _ADDR_LAT_7._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.MXN1 _ADDR_LAT_7._ADDR_LAT.ND TRA5
+  _ADDR_LAT_7._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN2 _ADDR_LAT_7._ADDR_LAT.ND RA5
+  _ADDR_LAT_7._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN5 _ADDR_LAT_7._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN6 _ADDR_LAT_7._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXP1 _ADDR_LAT_7._ADDR_LAT.ND RA5
+  _ADDR_LAT_7._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP3 _ADDR_LAT_7._ADDR_LAT.ND TRA5
+  _ADDR_LAT_7._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP4 _ADDR_LAT_7._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP5 _ADDR_LAT_7._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY _ADDR_LAT_8._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA2 _ADDR_LAT_8._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA2 _ADDR_LAT_8._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXNA1 LA_P2[1] NLA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXPA1 LA_P2[1] NLA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNA1 _ADDR_LAT_8._ADDR_LAT.I55.N1 LA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNOE NLA_P2[1] BCLK _ADDR_LAT_8._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPA1 _ADDR_LAT_8._ADDR_LAT.I55.P1 LA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPOEN NLA_P2[1] NCLK
+  _ADDR_LAT_8._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXNA1 LAY1 _ADDR_LAT_8._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXPA1 LAY1 _ADDR_LAT_8._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXNA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXPA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXNOE NLA_P2[1] NCLK _ADDR_LAT_8._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXPOEN NLA_P2[1] BCLK _ADDR_LAT_8._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.MXN1 _ADDR_LAT_8._ADDR_LAT.ND TLA1
+  _ADDR_LAT_8._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN2 _ADDR_LAT_8._ADDR_LAT.ND LA1
+  _ADDR_LAT_8._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN5 _ADDR_LAT_8._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN6 _ADDR_LAT_8._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXP1 _ADDR_LAT_8._ADDR_LAT.ND LA1
+  _ADDR_LAT_8._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP3 _ADDR_LAT_8._ADDR_LAT.ND TLA1
+  _ADDR_LAT_8._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP4 _ADDR_LAT_8._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP5 _ADDR_LAT_8._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_blprech.I51.MXNA1 _BLPRECH.DGTP_L _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXNA2 _BLPRECH.DGTP_L _BLPRECH.DRET VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXPA1 _BLPRECH.DGTP_L _BLPRECH.IGTP _BLPRECH.I51.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I51.MXPA2 _BLPRECH.I51.P1 _BLPRECH.DRET VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_blprech.I52.MXNA1 _BLPRECH.DGTP_R _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I52.MXNA2 _BLPRECH.DGTP_R RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I52.MXPA1 _BLPRECH.DGTP_R _BLPRECH.IGTP _BLPRECH.I52.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I52.MXPA2 _BLPRECH.I52.P1 RET VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I64.MXNA1 _BLPRECH.I64.N1 _BLPRECH.NET039 VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_blprech.I64.MXNOE _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_blprech.I64.MXPA1 _BLPRECH.I64.P1 _BLPRECH.NET039 VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_blprech.I64.MXPOEN _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_blprech.I65.MXNA1 _BLPRECH.I65.N1 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I65.MXNOE _BLPRECH.NET039 RET _BLPRECH.I65.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I65.MXPA1 _BLPRECH.I65.P1 RET VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_blprech.I65.MXPOEN _BLPRECH.NET039 RET _BLPRECH.I65.P1 VNWP P11LL_CKT
+  W=0.43U L=0.04U
X_M_blprech.I68.MXNA1 _BLPRECH.DRET _BLPRECH.NET49 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_blprech.I68.MXPA1 _BLPRECH.DRET _BLPRECH.NET49 VDDPE VNWP P11LL_CKT
+  W=0.345U L=0.04U
X_M_blprech.I69.MXNA1 _BLPRECH.NET49 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I69.MXNA2 _BLPRECH.NET49 _BLPRECH.NET047 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA1 _BLPRECH.NET49 RET _BLPRECH.I69.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA2 _BLPRECH.I69.P1 _BLPRECH.NET047 VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.MXN0 BLPRECH_R _BLPRECH.NBLPRECH_R VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN1 BLPRECH_L _BLPRECH.NBLPRECH_L VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN2 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXN4 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXP0 VDDPE RDT_RD VDDPE VNWP P11LL_CKT W=4.095U L=0.04U
X_M_blprech.MXP2 BLPRECH_R _BLPRECH.NBLPRECH_R VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP3 BLPRECH_L _BLPRECH.NBLPRECH_L VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP4 _BLPRECH.IGTP NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_blprech._aoi_bl_f.MXN0 _BLPRECH.NBLPRECH_L NGTP _BLPRECH._AOI_BL_F.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN1 _BLPRECH._AOI_BL_F.NET12 _BLPRECH.DGTP_L VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN2 _BLPRECH.NBLPRECH_L RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_f.MXP0 _BLPRECH.NBLPRECH_L NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_f.MXP1 _BLPRECH.NBLPRECH_L _BLPRECH.DGTP_L VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXN0 _BLPRECH.NBLPRECH_R NGTP _BLPRECH._AOI_BL_R.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN1 _BLPRECH._AOI_BL_R.NET12 _BLPRECH.DGTP_R VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN2 _BLPRECH.NBLPRECH_R RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_r.MXP0 _BLPRECH.NBLPRECH_R NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXP1 _BLPRECH.NBLPRECH_R _BLPRECH.DGTP_R VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_ckgen.I92.MXNA1 DWL _CKGEN.NGTP VSSE VPW N11LL_CKT W=2.13U L=0.04U
X_M_ckgen.I92.MXPA1 DWL _CKGEN.NGTP VDDP_CLKGEN VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckgen.Iema.I0.MXNA1 _CKGEN.IEMA.NGWE GWE_DFT _CKGEN.IEMA.I0.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXNA2 _CKGEN.IEMA.I0.N1 RET1N_WEMA00N VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXPA1 _CKGEN.IEMA.NGWE GWE_DFT VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckgen.Iema.I0.MXPA2 _CKGEN.IEMA.NGWE RET1N_WEMA00N VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I1.MXNA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I1.MXPA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=1.28U L=0.04U
X_M_ckgen.Iema.I2.MXNA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I2.MXPA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_ckgen.Iema.I20.MXNOE _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NRDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I20.MXPOEN _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NRDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXNOE _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NWDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXPOEN _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NWDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I40.MXNA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I40.MXPA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.I49.MXN3 _CKGEN.IEMA.I49.NET057 GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET049 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN4 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN8 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET057 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN9 _CKGEN.IEMA.I49.NET049 GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP0 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP1 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN
+  _CKGEN.IEMA.I49.NET044 VNWP P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP2 _CKGEN.IEMA.I49.NET044 _CKGEN.IEMA.I49.NDIN VDDPE VNWP
+  P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXNA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=1.03U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXPA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN3 _CKGEN.IEMA.IRMUX._RDLY0.NET40
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET045 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN8 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET40 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN9 _CKGEN.IEMA.IRMUX._RDLY0.NET045
+  _CKGEN.IEMA.IRMUX.CKMX1O VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP0 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP2 _CKGEN.IEMA.IRMUX._RDLY0.NET030
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN _CKGEN.IEMA.IRMUX._RDLY0.NET030 VNWP
+  P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN3 _CKGEN.IEMA.IRMUX._RDLY1.NET046
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET038 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN8 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET046 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN9 _CKGEN.IEMA.IRMUX._RDLY1.NET038
+  _CKGEN.IEMA.IRMUX.CKDLY2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP0 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP2 _CKGEN.IEMA.IRMUX._RDLY1.NET030
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN _CKGEN.IEMA.IRMUX._RDLY1.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN3 _CKGEN.IEMA.IRMUX._RDLY2.NET046 SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET038 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN8 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET046 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN9 _CKGEN.IEMA.IRMUX._RDLY2.NET038 SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP0 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP2 _CKGEN.IEMA.IRMUX._RDLY2.NET030
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN _CKGEN.IEMA.IRMUX._RDLY2.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RMX0.I12.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I12.N1
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 EMA[0]
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A1 EMA[0] VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2
+  _CKGEN.IEMA.IRMUX._RMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNB1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.NCK_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA2 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPB1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP
+  _CKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VPW
+  N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXNA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.936U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXPA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXNA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXPA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen.Iema._wdly0.MXN3 _CKGEN.IEMA._WDLY0.NET057 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN4 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXN8 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN9 _CKGEN.IEMA._WDLY0.NET049 _CKGEN.IEMA.WCLK00 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXP0 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXP1 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN
+  _CKGEN.IEMA._WDLY0.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly0.MXP2 _CKGEN.IEMA._WDLY0.NET044 _CKGEN.IEMA._WDLY0.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXN3 _CKGEN.IEMA._WDLY1.NET057 _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN4 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXN8 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN9 _CKGEN.IEMA._WDLY1.NET049 _CKGEN.IEMA.DWCLK10 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXP0 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXP1 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN
+  _CKGEN.IEMA._WDLY1.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXP2 _CKGEN.IEMA._WDLY1.NET044 _CKGEN.IEMA._WDLY1.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXN3 _CKGEN.IEMA._WDLY2.NET057 _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN4 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXN8 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN9 _CKGEN.IEMA._WDLY2.NET049 _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXP0 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXP1 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN
+  _CKGEN.IEMA._WDLY2.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXP2 _CKGEN.IEMA._WDLY2.NET044 _CKGEN.IEMA._WDLY2.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA2 _CKGEN.IEMA._WMX0.I12.N1
+  _CKGEN.IEMA._WMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA2 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA._WMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01
+  _CKGEN.IEMA._WMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA2 _CKGEN.IEMA._WMX0.I13.N1 EMAW[0] VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA2 _CKGEN.IEMA._WMX0.A1 EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA2 _CKGEN.IEMA._WMX0.I18.A1A2 _CKGEN.IEMA._WMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNB1 _CKGEN.IEMA.WDLY _CKGEN.IEMA.NCK_IN VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA2 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A1
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPB1 _CKGEN.IEMA._WMX0.I18.A1A2UP _CKGEN.IEMA.NCK_IN
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXNA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXPA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXNA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXPA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXNA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXPA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXNA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXPA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_IN VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_DLY VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXNA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXPA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen._memgtp.I1.MXNA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK
+  _CKGEN._MEMGTP.I1.N1 VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXNA2 _CKGEN._MEMGTP.I1.N1 RET1N VSSE VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXPA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK VDDPE VNWP
+  P11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXPA2 _CKGEN._MEMGTP.C1 RET1N VDDPE VNWP P11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I24.MXNA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNA2 _CKGEN._MEMGTP.I24.A1A2 _CKGEN._MEMGTP.NDFT VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNB1 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.C1 VSSE VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I24.MXPA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2UP
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPA2 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.NDFT
+  _CKGEN._MEMGTP.I24.A1A2UP VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPB1 _CKGEN._MEMGTP.I24.A1A2UP _CKGEN._MEMGTP.C1 VDDPE
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I6.MXNA1 GTP _CKGEN.NGTP VSSE VPW N11LL_CKT W=5.685U L=0.04U
X_M_ckgen._memgtp.I6.MXPA1 GTP _CKGEN.NGTP VDDPE VNWP P11LL_CKT W=11.37U
+  L=0.04U
X_M_ckgen._memgtp.I68.MXNA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen._memgtp.I68.MXPA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VDDPE VNWP
+  P11LL_CKT W=0.72U L=0.04U
X_M_ckgen._memgtp.I7.MXNA1 _CKGEN._MEMGTP.NCLK CLK VSS VPW N11LL_CKT W=4.26U
+  L=0.04U
X_M_ckgen._memgtp.I7.MXPA1 _CKGEN._MEMGTP.NCLK CLK VDDPE VNWP P11LL_CKT
+  W=4.26U L=0.04U
X_M_ckgen._memgtp.I74.MXNA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VSSE VPW
+  N11LL_CKT W=0.31U L=0.04U
X_M_ckgen._memgtp.I74.MXPA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen._memgtp.I82.MXNA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I82.MXPA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_M_ckgen._memgtp.I83.MXNA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2
+  _CKGEN._MEMGTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXNA2 _CKGEN._MEMGTP.I83.N1 _CKGEN.NET035 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXPA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I83.MXPA2 _CKGEN._MEMGTP.C3 _CKGEN.NET035 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I86.MXNA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I86.MXPA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.MXN0 _CKGEN._MEMGTP.NCLK _CKGEN._MEMGTP.CTR _CKGEN.NGTP VPW
+  N11LL_CKT W=4.25U L=0.04U
X_M_ckgen._memgtp.MXN7 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET114
+  VPW N11LL_CKT W=0.26U L=0.04U
X_M_ckgen._memgtp.MXN8 _CKGEN._MEMGTP.NET114 _CKGEN.RESET VSSE VPW N11LL_CKT
+  W=0.26U L=0.04U
X_M_ckgen._memgtp.MXP1 _CKGEN.NGTP _CKGEN.RESET VDDPE VNWP P11LL_CKT W=4.275U
+  L=0.04U
X_M_ckgen._memgtp.MXP2 _CKGEN._MEMGTP.NET127 _CKGEN._MEMGTP.CTR VDDPE VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen._memgtp.MXP3 _CKGEN._MEMGTP.NET127 CLK VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckgen._memgtp.MXP5 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET127
+  VNWP P11LL_CKT W=0.48U L=0.04U
X_M_dftram_lat.I47.MXNA1 _DFTRAM_LAT.ND IDFTRAMBYP VSS VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_dftram_lat.I47.MXPA1 _DFTRAM_LAT.ND IDFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.68U L=0.04U
X_M_dftram_lat.I48.MXNOE DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.ND VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I48.MXPOEN DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.ND VNWP P11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I50.MXNA1 DFTRAMBYP_LAT DFT_LAT_NQ VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_dftram_lat.I50.MXPA1 DFTRAMBYP_LAT DFT_LAT_NQ VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_dftram_lat.I55.MXNA1 _DFTRAM_LAT.I55.N1 DFTRAMBYP_LAT VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXNOE DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPA1 _DFTRAM_LAT.I55.P1 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPOEN DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY _GWEN_LAT._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA2 _GWEN_LAT._ADDR_LAT.I0.N1 IDFTRAMBYP VSS VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA2 _GWEN_LAT._ADDR_LAT.NDY IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXNA1 GWEN_LAT_Q GWEN_LAT_NQ VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXPA1 GWEN_LAT_Q GWEN_LAT_NQ VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNA1 _GWEN_LAT._ADDR_LAT.I55.N1 GWEN_LAT_Q VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNOE GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPA1 _GWEN_LAT._ADDR_LAT.I55.P1 GWEN_LAT_Q VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPOEN GWEN_LAT_NQ NCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXNA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXPA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXNA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXPA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXNOE GWEN_LAT_NQ NCLK_GTPSA _GWEN_LAT._ADDR_LAT.ND
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXPOEN GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.ND VNWP P11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.MXN1 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN2 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.N1
+  VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN5 _GWEN_LAT._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN6 _GWEN_LAT._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXP1 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.P1
+  VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP3 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP4 _GWEN_LAT._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP5 _GWEN_LAT._ADDR_LAT.P2 NTE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_rdt_lat.I47.MXNA1 _RDT_LAT.ND RDT VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I47.MXPA1 _RDT_LAT.ND RDT VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_M_rdt_lat.I48.MXNOE NRDT_LAT NCLK _RDT_LAT.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I48.MXPOEN NRDT_LAT BCLK _RDT_LAT.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_rdt_lat.I50.MXNA1 RDT_P2 NRDT_LAT VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_rdt_lat.I50.MXPA1 RDT_P2 NRDT_LAT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_rdt_lat.I55.MXNA1 _RDT_LAT.I55.N1 RDT_P2 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_rdt_lat.I55.MXNOE NRDT_LAT BCLK _RDT_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPA1 _RDT_LAT.I55.P1 RDT_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPOEN NRDT_LAT NCLK _RDT_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I14.MXNA1 NWCLK _WRITE.NET0102 VSS VPW N11LL_CKT W=5.53U L=0.04U
X_M_write.I14.MXPA1 NWCLK _WRITE.NET0102 VDDPE VNWP P11LL_CKT W=5.7U L=0.04U
X_M_write.I27.MXNA1 _WRITE.NET0102 _WRITE.NET66 VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_write.I27.MXPA1 _WRITE.NET0102 _WRITE.NET66 VDDPE VNWP P11LL_CKT W=2.13U
+  L=0.04U
X_M_write.I52.MXNA1 INWCLK_WT GTP _WRITE.I52.N2 VPW N11LL_CKT W=0.595U L=0.04U
X_M_write.I52.MXNA2 _WRITE.I52.N2 GWE_DFT _WRITE.I52.N1 VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXNA3 _WRITE.I52.N1 _WRITE.NET076 VSS VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXPA1 INWCLK_WT GTP VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA2 INWCLK_WT GWE_DFT VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA3 INWCLK_WT _WRITE.NET076 VDDPE VNWP P11LL_CKT W=0.51U
+  L=0.04U
X_M_write.I53.MXNA1 _WRITE.NET66 GTP _WRITE.I53.NET39 VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXNA2 _WRITE.NET66 _WRITE.DGTP _WRITE.I53.NET39 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_write.I53.MXNB1 _WRITE.I53.NET39 GWE_DFT VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXPA1 _WRITE.NET66 GTP _WRITE.I53.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPA2 _WRITE.I53.P1 _WRITE.DGTP VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPB1 _WRITE.NET66 GWE_DFT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_write.I61.MXNA1 _WRITE.NET035 WR_THRU VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_write.I61.MXNA2 _WRITE.NET035 IDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I61.MXPA1 _WRITE.NET035 WR_THRU _WRITE.I61.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I61.MXPA2 _WRITE.I61.P1 IDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I62.MXNA1 _WRITE.NET076 _WRITE.NET035 VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I62.MXPA1 _WRITE.NET076 _WRITE.NET035 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I64.MXNA1 GWE_DFT NGWE_DFT VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_write.I64.MXPA1 GWE_DFT NGWE_DFT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_write.MXN0 WRITE_NGTP DWL_DLY VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN3 _WRITE.NET037 WRITE_NGTP VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN8 _WRITE.DGTP WRITE_NGTP _WRITE.NET037 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_write.MXP0 _WRITE.DGTP WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP1 VDDPE DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP2 WRITE_NGTP DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ydec.I13.MXNA1 _YDEC.NGTP_DFT GTP _YDEC.I13.N1 VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA2 _YDEC.I13.N1 NDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXPA1 _YDEC.NGTP_DFT GTP VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_M_ydec.I13.MXPA2 _YDEC.NGTP_DFT NDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA1 _YDEC.CLK_WR _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA2 _YDEC.CLK_WR NGWE VSSE VPW N11LL_CKT W=0.71U L=0.04U
X_M_ydec.I7.MXPA1 _YDEC.CLK_WR _YDEC.NGTP_DFT _YDEC.I7.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I7.MXPA2 _YDEC.I7.P1 NGWE VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I8.MXNA1 _YDEC.CLK_RD _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec.I8.MXNA2 _YDEC.CLK_RD GWE_P2 VSSE VPW N11LL_CKT W=0.565U L=0.04U
X_M_ydec.I8.MXPA1 _YDEC.CLK_RD _YDEC.NGTP_DFT _YDEC.I8.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I8.MXPA2 _YDEC.I8.P1 GWE_P2 VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I9.MXNA1 NGWE GWE_P2 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ydec.I9.MXPA1 NGWE GWE_P2 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ydec._rmux_0.I39.MXNA1 NYR0 _YDEC._RMUX_0.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_0.I39.MXPA1 NYR0 _YDEC._RMUX_0.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_0.MXN0 _YDEC._RMUX_0.INYP NCADDR0 _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_0.MXN1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_0.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_0.MXP0 _YDEC._RMUX_0.INYP NCADDR0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ydec._rmux_0.MXP1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_0.MXP2 _YDEC._RMUX_0.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.I39.MXNA1 NYR1 _YDEC._RMUX_1.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_1.I39.MXPA1 NYR1 _YDEC._RMUX_1.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_1.MXN0 _YDEC._RMUX_1.INYP CADDR0 _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_1.MXN1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_1.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_1.MXP0 _YDEC._RMUX_1.INYP CADDR0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ydec._rmux_1.MXP1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_1.MXP2 _YDEC._RMUX_1.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._wmux_0.MXN0 _YDEC._WMUX_0.INYP NCADDR0 _YDEC.WN1 VPW N11LL_CKT
+  W=0.995U L=0.04U
X_M_ydec._wmux_0.MXN1 YW0 _YDEC._WMUX_0.INYP VSSE VPW N11LL_CKT W=3.18U
+  L=0.04U
X_M_ydec._wmux_0.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.995U
+  L=0.04U
X_M_ydec._wmux_0.MXP0 _YDEC._WMUX_0.INYP NCADDR0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ydec._wmux_0.MXP1 YW0 _YDEC._WMUX_0.INYP VDDPE VNWP P11LL_CKT W=7.94U
+  L=0.04U
X_M_ydec._wmux_0.MXP2 _YDEC._WMUX_0.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_1.MXN0 _YDEC._WMUX_1.INYP CADDR0 _YDEC.WN1 VPW N11LL_CKT
+  W=0.995U L=0.04U
X_M_ydec._wmux_1.MXN1 YW1 _YDEC._WMUX_1.INYP VSSE VPW N11LL_CKT W=3.18U
+  L=0.04U
X_M_ydec._wmux_1.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.995U
+  L=0.04U
X_M_ydec._wmux_1.MXP0 _YDEC._WMUX_1.INYP CADDR0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ydec._wmux_1.MXP1 YW1 _YDEC._WMUX_1.INYP VDDPE VNWP P11LL_CKT W=7.94U
+  L=0.04U
X_M_ydec._wmux_1.MXP2 _YDEC._WMUX_1.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
.ENDS RAMSP128X16CKM2_BIST
****
.SUBCKT RAMSP128X16CNTRL ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2
+  CEN CENY CLK CRE1 CRE2 DBL DFTRAM_RET DUMMY_DWL_R DUM_PEN DUM_PENSI
+  DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L
+  DUM_SEL_TD_R DUM_TPEN DWL EMAW0 EMAW1 EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1
+  FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4
+  FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP LA0 LA2 LAY0 LAY1 LAY2 LA_P2[0]
+  LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L
+  NSAO_R NWCLK NWCLK_BOT NWCLK_WT NYR0 NYR1 RA0 RA1 RA2 RA3 RA4 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5]
+  RET RET1N SAE_DUMMY SAPRECH SEL_D SEL_SI SEL_TD SO0 SO1 TCA1 TCA2 TE TLA2
+  TWEN VDDCE VDDC_LEFT VDDC_RIGHT VDDP VDDPE VPW WEN YW0 YW1
** RAMSP128X16CNTRL: 711 flat devices **
XCK ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2
+  DBL LOG0 DFTRAM_RET DUMMY_DWL_R DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0
+  DUM_PSO1 DUM_TPEN DWL EMAW0 EMAW1 EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2
+  FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5
+  FCA2_6 GTP GWEN GWENY IDFTRAMBYP RA_P2[5] LA0 LOG0 LA2 LAY0 LAY1 LAY2
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT
+  NSAE NSAO_L NSAO_R NWCLK NWCLK_WT NYR0 NYR1 RA0 RA1 RA2 RA3 RA4 LOG0 RAY0
+  RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4]
+  RA_P2[5] LOG0 RET RET1N SAE_DUMMY SAPRECH LOG0 SEL_D SEL_SI SEL_TD SO0 SO1
+  LOG0 TCA1 TCA2 LOG0 TE LOG1 LOG0 LOG0 LOG0 TLA2 LOG0 LOG0 LOG0 LOG0 LOG0
+  LOG0 VDDCE VDDCE VDDC_LEFT VDDCE VDDC_RIGHT VDDP VDDPE VDDPE VDDCE VDDPE
+  VPW VPW VPW LOG0 YW0 YW1 RAMSP128X16CKM2_BIST
.ENDS RAMSP128X16CNTRL
****
.SUBCKT RAMSP128X16IOCDM_R BL0_0 BL0_1 BL0_2 BL0_3 BL1_0 BL1_1 BL1_2 BL1_3
+  BL2_0 BL2_1 BL2_2 BL2_3 BL3_0 BL3_1 BL3_2 BL3_3 BLPRECH D0_0 D0_1 D0_2 D0_3
+  D1_0 D1_1 D1_2 D1_3 DFTRAMBYP DUM_NWCLK_L DUM_NWCLK_R DUM_SEL_D_L
+  DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L DUM_SEL_TD_R DWL LOG0
+  NACT_CC NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL2_0
+  NBL2_1 NBL2_2 NBL2_3 NBL3_0 NBL3_1 NBL3_2 NBL3_3 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAPRECH SEL_D
+  SEL_SI SEL_TD SI SO TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE
+  TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENL TWENR
+  VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VPW
+  WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENL WENR WENY0_0
+  WENY0_1 WENY0_2 WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1
** RAMSP128X16IOCDM_R: 1060 flat devices **
XR_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D0_1 D1_1 DFTRAMBYP DUM_NWCLK_L_14
+  DUM_NWCLK_R_0 DUM_SEL_D_L_16 DUM_SEL_D_R_2 DUM_SEL_SI_L_18 DUM_SEL_SI_R_4
+  DUM_SEL_TD_L_20 DUM_SEL_TD_R_6 DWL LOG0 NACT_CC NBL0_1 NBL1_1 NBL2_1 NBL3_1
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_1 SAO1_1 SAPRECH SEL_D SEL_SI SEL_TD
+  SI_22 SO_8 TD0_1 TD1_1 TE TWEN0_1 TWEN0_1 TWEN1_1 TWEN1_1 TWENL_24 TWENR_10
+  VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW WEN0_1 WEN0_1 WEN1_1 WEN1_1
+  WENL_26 WENR_12 WENY0_1 WENY1_1 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
XR_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D0_2 D1_2 DFTRAMBYP DUM_NWCLK_L_28
+  DUM_NWCLK_L_14 DUM_SEL_D_L_30 DUM_SEL_D_L_16 DUM_SEL_SI_L_32
+  DUM_SEL_SI_L_18 DUM_SEL_TD_L_34 DUM_SEL_TD_L_20 DWL LOG0 NACT_CC NBL0_2
+  NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_2 SAO1_2 SAPRECH
+  SEL_D SEL_SI SEL_TD SI_36 SI_22 TD0_2 TD1_2 TE TWEN0_2 TWEN0_2 TWEN1_2
+  TWEN1_2 TWENL_38 TWENL_24 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW
+  WEN0_2 WEN0_2 WEN1_2 WEN1_2 WENL_40 WENL_26 WENY0_2 WENY1_2 YW0 YW1
+  RAMSP128X16COLM2X2_BIST_WM
XR_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D0_0 D1_0 DFTRAMBYP DUM_NWCLK_R_0
+  DUM_NWCLK_R DUM_SEL_D_R_2 DUM_SEL_D_R DUM_SEL_SI_R_4 DUM_SEL_SI_R
+  DUM_SEL_TD_R_6 DUM_SEL_TD_R DWL LOG0 NACT_CC NBL0_0 NBL1_0 NBL2_0 NBL3_0
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_0 SAO1_0 SAPRECH SEL_D SEL_SI SEL_TD
+  SO_8 SO TD0_0 TD1_0 TE TWEN0_0 TWEN0_0 TWEN1_0 TWEN1_0 TWENR_10 TWENR
+  VDDC_0 VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW WEN0_0 WEN0_0 WEN1_0 WEN1_0
+  WENR_12 WENR WENY0_0 WENY1_0 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
XR_IO_R BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D0_3 D1_3 DFTRAMBYP DUM_NWCLK_L
+  DUM_NWCLK_L_28 DUM_SEL_D_L DUM_SEL_D_L_30 DUM_SEL_SI_L DUM_SEL_SI_L_32
+  DUM_SEL_TD_L DUM_SEL_TD_L_34 DWL LOG0 NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_3 SAO1_3 SAPRECH SEL_D SEL_SI SEL_TD SI
+  SI_36 TD0_3 TD1_3 TE TWEN0_3 TWEN0_3 TWEN1_3 TWEN1_3 TWENL TWENL_38 VDDC_3
+  VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW WEN0_3 WEN0_3 WEN1_3 WEN1_3 WENL
+  WENL_40 WENY0_3 WENY1_3 YW0 YW1 RAMSP128X16COLM2X2_BIST_WM
.ENDS RAMSP128X16IOCDM_R
****
.SUBCKT RAMSP128X16IO_RDM_R D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q1_0
+  Q1_1 Q1_2 Q1_3 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3
+  TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VPW_0 VPW_1
+  VPW_2 VPW_3 VSS_0 VSS_1 VSS_2 VSS_3 WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3
** RAMSP128X16IO_RDM_R: 16 flat devices **
XR_RDM_1 D0_1 D1_1 DUM_SEL_D_L_4 DUM_SEL_D_L_0 DUM_SEL_TD_L_6 DUM_SEL_TD_L_2
+  Q0_1 Q1_1 SAO0_1 SAO1_1 TD0_1 TD1_1 TWEN0_1 TWEN1_1 VDDCE_1 VDDPE_1 VNWP_1
+  VPW_1 VSS_1 VSS_1 WEN0_1 WEN1_1 WENY0_1 WENY1_1 RAMSP128X16RDM2X2
XR_RDM_2 D0_2 D1_2 DUM_SEL_D_R_8 DUM_SEL_D_L_4 DUM_SEL_TD_R_10 DUM_SEL_TD_L_6
+  Q0_2 Q1_2 SAO0_2 SAO1_2 TD0_2 TD1_2 TWEN0_2 TWEN1_2 VDDCE_2 VDDPE_2 VNWP_2
+  VPW_2 VSS_2 VSS_2 WEN0_2 WEN1_2 WENY0_2 WENY1_2 RAMSP128X16RDM2X2
XR_RDM_L D0_0 D1_0 DUM_SEL_D_L_0 DUM_SEL_D_R DUM_SEL_TD_L_2 DUM_SEL_TD_R Q0_0
+  Q1_0 SAO0_0 SAO1_0 TD0_0 TD1_0 TWEN0_0 TWEN1_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0
+  VSS_0 VSS_0 WEN0_0 WEN1_0 WENY0_0 WENY1_0 RAMSP128X16RDM2X2
XR_RDM_R D0_3 D1_3 DUM_SEL_D_L DUM_SEL_D_R_8 DUM_SEL_TD_L DUM_SEL_TD_R_10 Q0_3
+  Q1_3 SAO0_3 SAO1_3 TD0_3 TD1_3 TWEN0_3 TWEN1_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3
+  VSS_3 VSS_3 WEN0_3 WEN1_3 WENY0_3 WENY1_3 RAMSP128X16RDM2X2
.ENDS RAMSP128X16IO_RDM_R
****
.SUBCKT RAMSP128X16IOTOPCAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VPW
** RAMSP128X16IOTOPCAP_R: 128 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP128X16CCHD4_TOPBOT
.ENDS RAMSP128X16IOTOPCAP_R
****
.SUBCKT RAMSP128X16IO_ROW_R BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DFTRAMBYP
+  DUM_NWCLK_R DUM_SEL_D_R_0 DUM_SEL_D_R_1 DUM_SEL_SI_R DUM_SEL_TD_R_0
+  DUM_SEL_TD_R_1 DWL LOG0_0 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NSAE NWCLK NWCLK_WT NYR0 NYR1
+  Q0_0 Q0_1 Q0_2 Q0_3 Q1_0 Q1_1 Q1_2 Q1_3 SAPRECH SEL_D SEL_SI SEL_TD SO
+  TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENR VDDC VDDPE VPW WEN0_0 WEN0_1
+  WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENR WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1
** RAMSP128X16IO_ROW_R: 1209 flat devices **
XIO_CDM_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BLPRECH
+  D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DFTRAMBYP DUM_NWCLK_L DUM_NWCLK_R
+  DUM_SEL_D_L DUM_SEL_D_R_1 DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L
+  DUM_SEL_TD_R_1 DWL LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NSAE NWCLK NWCLK_WT NYR0 NYR1 SAO0_0
+  SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAPRECH SEL_D SEL_SI
+  SEL_TD LOG0_0 SO TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TE TWEN0_0
+  TWEN0_1 TWEN0_2 TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWENL TWENR VDDC
+  VDDC VDDC VDDC VDDC VDDPE VDDC VDDC VDDC VDDC VPW WEN0_0 WEN0_1 WEN0_2
+  WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENL WENR WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3 YW0 YW1 RAMSP128X16IOCDM_R
XIO_EDGE_R BLPRECH DFTRAMBYP DUM_NWCLK_L DUM_SEL_D_0 DUM_SEL_D_L DUM_SEL_SI_L
+  DUM_SEL_TD_0 DUM_SEL_TD_L DWL LOG0_1 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1
+  SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL VDDC VDDC VDDPE VDDC VPW VPW
+  WENL YW0 YW1 RAMSP128X16IOEDGE
XIO_RDM_ROW_R D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DUM_SEL_D_0
+  DUM_SEL_D_R_0 DUM_SEL_TD_0 DUM_SEL_TD_R_0 Q0_0 Q0_1 Q0_2 Q0_3 Q1_0 Q1_1
+  Q1_2 Q1_3 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO1_0 SAO1_1 SAO1_2 SAO1_3 TD0_0
+  TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2 TD1_3 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3
+  TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 VDDC VDDC VDDC VDDC VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW WEN0_0 WEN0_1
+  WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WENY0_0 WENY0_1 WENY0_2 WENY0_3
+  WENY1_0 WENY1_1 WENY1_2 WENY1_3 RAMSP128X16IO_RDM_R
XIO_TOPCAP_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDC VDDPE VDDPE VDDPE VDDPE VPW RAMSP128X16IOTOPCAP_R
.ENDS RAMSP128X16IO_ROW_R
****
.SUBCKT RAMSP128X16IO_SLICE ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 CA0
+  CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 DBL DFTRAM_RET
+  DUMMY_DWL_R DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL
+  EMAW0 EMAW1 EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5
+  FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY LA0
+  LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_1 LOG0_2 LOG0_DWL
+  LOG1 NACTC NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5
+  NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5
+  NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NGWE NRETNVT NWCLK_BOT Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6
+  Q0_7 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 RA0 RA1 RA2 RA3 RA4 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5]
+  RET RET1N SAE_DUMMY SEL_D SEL_SI SEL_TD SO0 SO1 TCA1 TCA2 TD0_0 TD0_1 TD0_2
+  TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6
+  TD1_7 TLA2 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7
+  TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7 VDDC VDDP
+  VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1 WENY1_2 WENY1_3
+  WENY1_4 WENY1_5 WENY1_6 WENY1_7
** RAMSP128X16IO_SLICE: 3129 flat devices **
XCK_BLK ACTP BLPRECH BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DBL DFTRAM_RET DUMMY_DWL_R DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0
+  DUM_PSO1 DUM_SEL_D_R_0 DUM_SEL_D_R DUM_SEL_TD_R_0 DUM_SEL_TD_R DUM_TPEN DWL
+  EMAW0 EMAW1 EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5
+  FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY
+  DFTRAMBYP LA0 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_DWL
+  LOG1 NACTC NACT_CC NGWE NRETNVT NSAE SO NSAO_R DUM_NWCLK_R NWCLK_BOT
+  NWCLK_WT NYR0 NYR1 RA0 RA1 RA2 RA3 RA4 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RET RET1N SAE_DUMMY
+  SAPRECH SEL_D SEL_SI SEL_TD SO0 SO1 TCA1 TCA2 TE TLA2 WENR VDDC VDDC VDDC
+  VDDP VDDPE VPW TWENR YW0 YW1 RAMSP128X16CNTRL
XIO_LEFT BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  D0_0 D0_1 D0_2 D0_3 D1_0 D1_1 D1_2 D1_3 DFTRAMBYP DUM_NWCLK_R DUM_SEL_D_R_0
+  SEL_D SEL_SI DUM_SEL_TD_R_0 SEL_TD LOG0_0 LOG0_1 LOG0_0 NACT_CC NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NSAE
+  DUM_NWCLK_R NWCLK_WT NYR0 NYR1 Q0_0 Q0_1 Q0_2 Q0_3 Q1_0 Q1_1 Q1_2 Q1_3
+  SAPRECH SEL_D SEL_SI SEL_TD SO TD0_0 TD0_1 TD0_2 TD0_3 TD1_0 TD1_1 TD1_2
+  TD1_3 TE TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3
+  TWENR VDDC VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN1_0 WEN1_1 WEN1_2
+  WEN1_3 WENR WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY1_0 WENY1_1 WENY1_2 WENY1_3
+  YW0 YW1 RAMSP128X16IO_ROW_L
XIO_RIGHT BLPRECH_R BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  D0_4 D0_5 D0_6 D0_7 D1_4 D1_5 D1_6 D1_7 DFTRAMBYP DUM_NWCLK_R DUM_SEL_D_R
+  SEL_D SEL_SI DUM_SEL_TD_R SEL_TD DWL LOG0_2 LOG0_0 NACT_CC NBL[0]_4
+  NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_4
+  NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NSAE
+  DUM_NWCLK_R NWCLK_WT NYR0 NYR1 Q0_4 Q0_5 Q0_6 Q0_7 Q1_4 Q1_5 Q1_6 Q1_7
+  SAPRECH SEL_D SEL_SI SEL_TD NSAO_R TD0_4 TD0_5 TD0_6 TD0_7 TD1_4 TD1_5
+  TD1_6 TD1_7 TE TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN1_4 TWEN1_5 TWEN1_6
+  TWEN1_7 TWENR VDDC VDDPE VPW WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN1_4 WEN1_5
+  WEN1_6 WEN1_7 WENR WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_4 WENY1_5 WENY1_6
+  WENY1_7 YW0 YW1 RAMSP128X16IO_ROW_R
.ENDS RAMSP128X16IO_SLICE
****
.SUBCKT RAMSP128X16CCHD4_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP128X16CCHD4_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP128X16CCHD4_EDG
****
.SUBCKT RAMSP128X16CCHD4WD_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP128X16CCHD4WD_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP128X16CCHD4WD_EDG
****
.SUBCKT RAMSP128X16CCHD4 BL[0] BL[1] BL[2] BL[3] CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0] NBL[1] NBL[2] NBL[3]
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC VDDCE VDDPE VNWC VPW VSSE WL[0] WL[1]
** RAMSP128X16CCHD4: 48 flat devices **
X_MI17._cell.MXN0 NCORED30 CORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXN1 NBL[3] WL[0] NCORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN2 BL[3] WL[0] CORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN3 CORED30 NCORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXP0 NCORED30 CORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI17._cell.MXP1 CORED30 NCORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXN0 NCORED20 CORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXN1 NBL[2] WL[0] NCORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN2 BL[2] WL[0] CORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN3 CORED20 NCORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXP0 NCORED20 CORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXP1 CORED20 NCORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXN0 NCORED10 CORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXN1 NBL[1] WL[0] NCORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN2 BL[1] WL[0] CORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN3 CORED10 NCORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXP0 NCORED10 CORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXP1 CORED10 NCORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXN0 NCORED00 CORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXN1 NBL[0] WL[0] NCORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN2 BL[0] WL[0] CORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN3 CORED00 NCORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXP0 NCORED00 CORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXP1 CORED00 NCORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_M_cell01._cell.MXN0 NCORED01 CORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXN1 NBL[0] WL[1] NCORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN2 BL[0] WL[1] CORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN3 CORED01 NCORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXP0 NCORED01 CORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell01._cell.MXP1 CORED01 NCORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXN0 NCORED11 CORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXN1 NBL[1] WL[1] NCORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN2 BL[1] WL[1] CORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN3 CORED11 NCORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXP0 NCORED11 CORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXP1 CORED11 NCORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXN0 NCORED21 CORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXN1 NBL[2] WL[1] NCORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN2 BL[2] WL[1] CORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN3 CORED21 NCORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXP0 NCORED21 CORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXP1 CORED21 NCORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXN0 NCORED31 CORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXN1 NBL[3] WL[1] NCORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN2 BL[3] WL[1] CORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN3 CORED31 NCORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXP0 NCORED31 CORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXP1 CORED31 NCORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
.ENDS RAMSP128X16CCHD4
****
.SUBCKT RAMSP128X16MEM_L_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_ROW: 196 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
.ENDS RAMSP128X16MEM_L_ROW
****
.SUBCKT RAMSP128X16MEM_L_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_MIDT_ROW: 196 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
.ENDS RAMSP128X16MEM_L_MIDT_ROW
****
.SUBCKT RAMSP128X16CCHD4WD_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP128X16CCHD4WD_CORNER: 3 flat devices **
X_MXN0 VSSE NET19 NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET15 NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP128X16CCHD4WD_CORNER
****
.SUBCKT RAMSP128X16MEM_SLICE_CAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VSSE
** RAMSP128X16MEM_SLICE_CAP_L: 134 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VSSE VSSE RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VSSE VSSE RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VSSE VSSE RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VSSE VSSE RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VDDC VDDC VNWP_0 VSSE VSSE RAMSP128X16CCHD4_CORNER
XTOP_EDGE_ROWEDGER VDDC VDDC VNWP_1 VSSE VSSE RAMSP128X16CCHD4WD_CORNER
.ENDS RAMSP128X16MEM_SLICE_CAP_L
****
.SUBCKT RAMSP128X16MEM_L_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_MID_ROW: 196 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
.ENDS RAMSP128X16MEM_L_MID_ROW
****
.SUBCKT RAMSP128X16MEM_L_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_BOT_ROW: 196 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_1 VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_0
+  NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_0 VDDCE_0 VDDPE_0
+  VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_BOT_R BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3
+  NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
.ENDS RAMSP128X16MEM_L_BOT_ROW
****
.SUBCKT RAMSP128X16MEM_L_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_TOP_ROW: 196 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_L_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_TOP_R BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_3
+  NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
.ENDS RAMSP128X16MEM_L_TOP_ROW
****
.SUBCKT RAMSP128X16MEM_L_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL[0] WL[1]
** RAMSP128X16MEM_L_MIDB_ROW: 196 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP128X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_5 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
.ENDS RAMSP128X16MEM_L_MIDB_ROW
****
.SUBCKT RAMSP128X16MEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VSSE WL[0]_0
+  WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9
+  WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17
+  WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25
+  WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[1]_0 WL[1]_1
+  WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10
+  WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18
+  WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26
+  WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31
** RAMSP128X16MEMCORE_L: 6406 flat devices **
XMEM_L_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_1 WL[1]_1
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_10
+  WL[1]_10 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_11
+  WL[1]_11 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_12
+  WL[1]_12 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_13
+  WL[1]_13 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_17
+  WL[1]_17 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_18
+  WL[1]_18 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_19
+  WL[1]_19 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_2 WL[1]_2
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_20
+  WL[1]_20 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_21
+  WL[1]_21 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_22
+  WL[1]_22 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_23
+  WL[1]_23 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_24
+  WL[1]_24 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_25
+  WL[1]_25 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_26
+  WL[1]_26 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_27
+  WL[1]_27 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_28
+  WL[1]_28 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_29
+  WL[1]_29 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_3 WL[1]_3
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_30
+  WL[1]_30 RAMSP128X16MEM_L_ROW
XMEM_L_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_4 WL[1]_4
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_5 WL[1]_5
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_6 WL[1]_6
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_7 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_7 WL[1]_7
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_8 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_8 WL[1]_8
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_9 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_9 WL[1]_9
+  RAMSP128X16MEM_L_ROW
XMEM_L_ROW_BOT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_0 WL[1]_0
+  RAMSP128X16MEM_L_BOT_ROW
XMEM_L_ROW_CAP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VSSE RAMSP128X16MEM_SLICE_CAP_L
XMEM_L_ROW_MID BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_15
+  WL[1]_15 RAMSP128X16MEM_L_MID_ROW
XMEM_L_ROW_MIDB BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE
+  WL[0]_14 WL[1]_14 RAMSP128X16MEM_L_MIDB_ROW
XMEM_L_ROW_MIDT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE
+  WL[0]_16 WL[1]_16 RAMSP128X16MEM_L_MIDT_ROW
XMEM_L_ROW_TOP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE WL[0]_31
+  WL[1]_31 RAMSP128X16MEM_L_TOP_ROW
.ENDS RAMSP128X16MEMCORE_L
****
.SUBCKT RAMSP128X16MEM_R_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_MIDB_ROW: 196 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
.ENDS RAMSP128X16MEM_R_MIDB_ROW
****
.SUBCKT RAMSP128X16MEM_R_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_ROW: 196 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
.ENDS RAMSP128X16MEM_R_ROW
****
.SUBCKT RAMSP128X16MEM_R_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_MIDT_ROW: 196 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
.ENDS RAMSP128X16MEM_R_MIDT_ROW
****
.SUBCKT RAMSP128X16MEM_SLICE_CAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC VNWP_0 VNWP_1 VPW
** RAMSP128X16MEM_SLICE_CAP_R: 134 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VNWC VNWC VDDPE_0 VNWC VPW VPW RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VNWC VNWC VDDPE_1 VNWC VPW VPW RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VNWC VNWC VDDPE_2 VNWC VPW VPW RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VNWC VNWC VDDPE_3 VNWC VPW VPW RAMSP128X16CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VNWC VNWC VNWP_0 VPW VPW RAMSP128X16CCHD4WD_CORNER
XTOP_EDGE_ROWEDGER VNWC VNWC VNWP_1 VPW VPW RAMSP128X16CCHD4_CORNER
.ENDS RAMSP128X16MEM_SLICE_CAP_R
****
.SUBCKT RAMSP128X16MEM_R_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_MID_ROW: 196 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
.ENDS RAMSP128X16MEM_R_MID_ROW
****
.SUBCKT RAMSP128X16MEM_R_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_BOT_ROW: 196 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_0
+  NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_BOT_R BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_3 VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
.ENDS RAMSP128X16MEM_R_BOT_ROW
****
.SUBCKT RAMSP128X16MEM_R_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 WL[0] WL[1]
** RAMSP128X16MEM_R_TOP_ROW: 196 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_5 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4_EDG
XMEM_R_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
XMEM_R_COL_TOP_R BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_3
+  NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP128X16CCHD4
.ENDS RAMSP128X16MEM_R_TOP_ROW
****
.SUBCKT RAMSP128X16MEMCORE_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VPW WL[0]_0
+  WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9
+  WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17
+  WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25
+  WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[1]_0 WL[1]_1
+  WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10
+  WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18
+  WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26
+  WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31
** RAMSP128X16MEMCORE_R: 6406 flat devices **
XMEM_R_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_1 WL[1]_1
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_10 WL[1]_10
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_11 WL[1]_11
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_12 WL[1]_12
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_13 WL[1]_13
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_17 WL[1]_17
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_18 WL[1]_18
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_19 WL[1]_19
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_2 WL[1]_2
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_20 WL[1]_20
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_21 WL[1]_21
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_22 WL[1]_22
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_23 WL[1]_23
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_24 WL[1]_24
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_25 WL[1]_25
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_26 WL[1]_26
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_27 WL[1]_27
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_28 WL[1]_28
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_29 WL[1]_29
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_3 WL[1]_3
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_30 WL[1]_30
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_4 WL[1]_4
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_5 WL[1]_5
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_6 WL[1]_6
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_7 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_7 WL[1]_7
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_8 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_8 WL[1]_8
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_9 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_9 WL[1]_9
+  RAMSP128X16MEM_R_ROW
XMEM_R_ROW_BOT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_0 WL[1]_0
+  RAMSP128X16MEM_R_BOT_ROW
XMEM_R_ROW_CAP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDC VNWP_0 VNWP_1 VPW RAMSP128X16MEM_SLICE_CAP_R
XMEM_R_ROW_MID BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_15 WL[1]_15
+  RAMSP128X16MEM_R_MID_ROW
XMEM_R_ROW_MIDB BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_14
+  WL[1]_14 RAMSP128X16MEM_R_MIDB_ROW
XMEM_R_ROW_MIDT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDC VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_16
+  WL[1]_16 RAMSP128X16MEM_R_MIDT_ROW
XMEM_R_ROW_TOP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW WL[0]_31 WL[1]_31
+  RAMSP128X16MEM_R_TOP_ROW
.ENDS RAMSP128X16MEMCORE_R
****
.SUBCKT RAMSP128X16WDTOP ACTP DBL LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5 NI6
+  NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0
+  NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET ROWCLK0 ROWCLK1
+  ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VDDCE VDDC_LEFT VDDC_RIGHT
+  VDDC_WL VDDP VDDPE VNWC VNWP VPW VSS VSSE
** RAMSP128X16WDTOP: 5 flat devices **
X_MXP2 NET108 RET VDDCE VNWC P11LL_CKT W=5.68U L=0.04U
X_M_wl_tcap_0.MXN0 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_0.MXP2 NI0 ROWCLK0 NET108 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_1.MXN0 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_1.MXP2 NI1 ROWCLK1 NET108 VNWC P11LL_CKT W=1.56U L=0.04U
.ENDS RAMSP128X16WDTOP
****
.SUBCKT RAMSP128X16WDX32 ACTP A[0] A[1] A[2] A[3] A[4] A[5] DBL DFTRAM_RET DWL
+  EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL
+  LOG1 NACTC NACT_CC NGWE NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0
+  NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2
+  NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3
+  ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 SAE_DUMMY VDDCE VDDC_L VDDC_R VDDP VDDPE
+  VNWC VNWP VPW VSS VSSE WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11
+  WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26
+  WL27 WL28 WL29 WL30 WL31
** RAMSP128X16WDX32: 576 flat devices **
X_MI31.MXNA1 XROW[1] XROW[0] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI31.MXPA1 XROW[1] XROW[0] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI35_0.MXNA1 IA[0] NA[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI35_0.MXPA1 IA[0] NA[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI35_1.MXNA1 IA[1] NA[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI35_1.MXPA1 IA[1] NA[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI35_2.MXNA1 IA[2] NA[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI35_2.MXPA1 IA[2] NA[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI36_0.MXNA1 NA[0] A[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI36_0.MXPA1 NA[0] A[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI36_1.MXNA1 NA[1] A[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI36_1.MXPA1 NA[1] A[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI36_2.MXNA1 NA[2] A[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI36_2.MXPA1 NA[2] A[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47.MXNA1 XROW[0] LA_P2[0] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI47.MXPA1 XROW[0] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI48.MXN0 IZERO I48.NODEB VSSE VPW N11LL_CKT W=0.51U L=0.04U
X_MI48.MXN1 I48.NODEA I48.NODEA VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXN2 I48.NODEA I48.NODEB VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXP1 I48.NODEB I48.NODEA VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_MI48.MXP4 IONE I48.NODEA VDDPE VNWP P11LL_CKT W=1.04U L=0.04U
X_MI53.MXNA1 NACT_CC ACT_CC VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_MI53.MXPA1 NACT_CC ACT_CC VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MI54.MXNA1 ACT_CC RET VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MI54.MXPA1 ACT_CC RET VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MInv_add_2_3.MXNA1 IA[3] NA[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_3.MXPA1 IA[3] NA[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_4.MXNA1 IA[4] NA[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_4.MXPA1 IA[4] NA[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_5.MXNA1 IA[5] NA[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_5.MXPA1 IA[5] NA[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_3.MXNA1 NA[3] A[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_3.MXPA1 NA[3] A[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_4.MXNA1 NA[4] A[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_4.MXPA1 NA[4] A[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_5.MXNA1 NA[5] A[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_5.MXPA1 NA[5] A[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MXN5 LOG0 IONE VSSE VPW N11LL_CKT W=3.98U L=0.04U
X_MXN7 LOG0_DWL IONE VSSE VPW N11LL_CKT W=2.84U L=0.04U
X_MXP4 LOG1 IZERO VDDPE VNWP P11LL_CKT W=5.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXNA1 SAE_DUMMY DBL VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXPA1 SAE_DUMMY DBL VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cmuxsa_dummy.MXN0 VSS DBL VSS VPW N11LL_CKT W=1.875U L=0.085U
X_M_cmuxsa_dummy.MXN1 VSS DBL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cmuxsa_dummy.MXN4_0 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXN4_1 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXP1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP2 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cmuxsa_dummy.MXP3 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_dbl_load_0.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_0.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dummy.I2.MXNA1 _DUMMY.NSEL0 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I2.MXNA2 _DUMMY.NSEL0 EMA0 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I2.MXPA1 _DUMMY.NSEL0 EMA2 _DUMMY.I2.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I2.MXPA2 _DUMMY.I2.P1 EMA0 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.I73.MXNA1 _DUMMY.NIDBL DBL VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I73.MXPA1 _DUMMY.NIDBL DBL VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_dummy.I77.MXNA1 _DUMMY.NSEL1 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I77.MXNA2 _DUMMY.NSEL1 EMA1 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I77.MXPA1 _DUMMY.NSEL1 EMA2 _DUMMY.I77.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I77.MXPA2 _DUMMY.I77.P1 EMA1 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.MXN19 DBL DWL _DUMMY.IA[0] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN20 _DUMMY.IA[0] LOG1 I[0] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN21 I[0] LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN22 DBL DWL _DUMMY.IA[1] VPW N11LL_CKT W=0.45U L=0.04U
X_M_dummy.MXN23 _DUMMY.IA[1] _DUMMY.NSEL0 I[1] VPW N11LL_CKT W=0.45U L=0.04U
X_M_dummy.MXN24 I[1] LOG1 VSSE VPW N11LL_CKT W=0.45U L=0.04U
X_M_dummy.MXN25 DBL DWL _DUMMY.IA[2] VPW N11LL_CKT W=1U L=0.04U
X_M_dummy.MXN26 _DUMMY.IA[2] _DUMMY.NSEL1 I[2] VPW N11LL_CKT W=1U L=0.04U
X_M_dummy.MXN27 I[2] LOG1 VSSE VPW N11LL_CKT W=1U L=0.04U
X_M_dummy.MXN28 DBL DWL _DUMMY.IA[3] VPW N11LL_CKT W=0.28U L=0.04U
X_M_dummy.MXN29 _DUMMY.IA[3] LOG1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_dummy.MXN30 VSSE LOG1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_dummy.MXN31 DBL DWL _DUMMY.IA[4] VPW N11LL_CKT W=0.51U L=0.04U
X_M_dummy.MXN32 _DUMMY.IA[4] LOG1 VSSE VPW N11LL_CKT W=0.51U L=0.04U
X_M_dummy.MXN33 VSSE LOG1 VSSE VPW N11LL_CKT W=0.51U L=0.04U
X_M_dummy.MXP10 _DUMMY.NET53 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP12 DBL DWL VDDPE VNWP P11LL_CKT W=2.485U L=0.04U
X_M_dummy.MXP7 _DUMMY.NET057 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP8 DBL LOG1 _DUMMY.NET057 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.MXP9 DBL LOG1 _DUMMY.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_rowdrv_0.I2.MXNA1 _ROWDRV_0.NROWCLK GTPCLK0 _ROWDRV_0.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_0.I2.MXNA2 _ROWDRV_0.I2.N1 XROW[0] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA1 _ROWDRV_0.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA2 _ROWDRV_0.NROWCLK XROW[0] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXNA1 ROWCLK0 _ROWDRV_0.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXPA1 ROWCLK0 _ROWDRV_0.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_0.MXN0 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_1.I2.MXNA1 _ROWDRV_1.NROWCLK GTPCLK1 _ROWDRV_1.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_1.I2.MXNA2 _ROWDRV_1.I2.N1 XROW[1] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA1 _ROWDRV_1.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA2 _ROWDRV_1.NROWCLK XROW[1] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXNA1 ROWCLK1 _ROWDRV_1.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXPA1 ROWCLK1 _ROWDRV_1.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_1.MXN0 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wd0.I69.MX_npd _WD0.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd0.I69._nr.MXNA1 _WD0.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXNA2 _WD0.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXPA1 _WD0.ROWSEL NXP0_0 _WD0.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd0.I69._nr.MXPA2 _WD0.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_0.MXN11 WL0 _WD0._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN8 _WD0._ROWDRV_0.NWL _WD0.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_0.MXP1 WL0 _WD0._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_0.MXP12 _WD0._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_0.MXP13 _WD0._ROWDRV_0.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd0._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_1.MXN11 WL1 _WD0._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_1.MXN8 _WD0._ROWDRV_1.NWL _WD0.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_1.MXP1 WL1 _WD0._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_1.MXP12 _WD0._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_1.MXP13 _WD0._ROWDRV_1.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1.I69.MX_npd _WD1.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd1.I69._nr.MXNA1 _WD1.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXNA2 _WD1.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXPA1 _WD1.ROWSEL NXP0_1 _WD1.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd1.I69._nr.MXPA2 _WD1.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_0.MXN11 WL2 _WD1._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN8 _WD1._ROWDRV_0.NWL _WD1.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_0.MXP1 WL2 _WD1._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_0.MXP12 _WD1._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_0.MXP13 _WD1._ROWDRV_0.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_1.MXN11 WL3 _WD1._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_1.MXN8 _WD1._ROWDRV_1.NWL _WD1.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_1.MXP1 WL3 _WD1._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_1.MXP12 _WD1._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_1.MXP13 _WD1._ROWDRV_1.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10.I69.MX_npd _WD10.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10.I69._nr.MXNA1 _WD10.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXNA2 _WD10.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXPA1 _WD10.ROWSEL NXP0_2 _WD10.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd10.I69._nr.MXPA2 _WD10.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_0.MXN11 WL20 _WD10._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN8 _WD10._ROWDRV_0.NWL _WD10.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_0.MXP1 WL20 _WD10._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_0.MXP12 _WD10._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_0.MXP13 _WD10._ROWDRV_0.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_1.MXN11 WL21 _WD10._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_1.MXN8 _WD10._ROWDRV_1.NWL _WD10.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_1.MXP1 WL21 _WD10._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_1.MXP12 _WD10._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_1.MXP13 _WD10._ROWDRV_1.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11.I69.MX_npd _WD11.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11.I69._nr.MXNA1 _WD11.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXNA2 _WD11.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXPA1 _WD11.ROWSEL NXP0_3 _WD11.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd11.I69._nr.MXPA2 _WD11.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_0.MXN11 WL22 _WD11._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN8 _WD11._ROWDRV_0.NWL _WD11.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_0.MXP1 WL22 _WD11._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_0.MXP12 _WD11._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_0.MXP13 _WD11._ROWDRV_0.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_1.MXN11 WL23 _WD11._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_1.MXN8 _WD11._ROWDRV_1.NWL _WD11.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_1.MXP1 WL23 _WD11._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_1.MXP12 _WD11._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_1.MXP13 _WD11._ROWDRV_1.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12.I69.MX_npd _WD12.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12.I69._nr.MXNA1 _WD12.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXNA2 _WD12.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXPA1 _WD12.ROWSEL NXP0_4 _WD12.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd12.I69._nr.MXPA2 _WD12.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_0.MXN11 WL24 _WD12._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN8 _WD12._ROWDRV_0.NWL _WD12.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_0.MXP1 WL24 _WD12._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_0.MXP12 _WD12._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_0.MXP13 _WD12._ROWDRV_0.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_1.MXN11 WL25 _WD12._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_1.MXN8 _WD12._ROWDRV_1.NWL _WD12.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_1.MXP1 WL25 _WD12._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_1.MXP12 _WD12._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_1.MXP13 _WD12._ROWDRV_1.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13.I69.MX_npd _WD13.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13.I69._nr.MXNA1 _WD13.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXNA2 _WD13.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXPA1 _WD13.ROWSEL NXP0_5 _WD13.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd13.I69._nr.MXPA2 _WD13.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_0.MXN11 WL26 _WD13._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN8 _WD13._ROWDRV_0.NWL _WD13.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_0.MXP1 WL26 _WD13._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_0.MXP12 _WD13._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_0.MXP13 _WD13._ROWDRV_0.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_1.MXN11 WL27 _WD13._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_1.MXN8 _WD13._ROWDRV_1.NWL _WD13.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_1.MXP1 WL27 _WD13._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_1.MXP12 _WD13._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_1.MXP13 _WD13._ROWDRV_1.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14.I69.MX_npd _WD14.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14.I69._nr.MXNA1 _WD14.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXNA2 _WD14.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXPA1 _WD14.ROWSEL NXP0_6 _WD14.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd14.I69._nr.MXPA2 _WD14.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_0.MXN11 WL28 _WD14._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN8 _WD14._ROWDRV_0.NWL _WD14.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_0.MXP1 WL28 _WD14._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_0.MXP12 _WD14._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_0.MXP13 _WD14._ROWDRV_0.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_1.MXN11 WL29 _WD14._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_1.MXN8 _WD14._ROWDRV_1.NWL _WD14.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_1.MXP1 WL29 _WD14._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_1.MXP12 _WD14._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_1.MXP13 _WD14._ROWDRV_1.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2.I69.MX_npd _WD2.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd2.I69._nr.MXNA1 _WD2.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXNA2 _WD2.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXPA1 _WD2.ROWSEL NXP0_2 _WD2.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd2.I69._nr.MXPA2 _WD2.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_0.MXN11 WL4 _WD2._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN8 _WD2._ROWDRV_0.NWL _WD2.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_0.MXP1 WL4 _WD2._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_0.MXP12 _WD2._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_0.MXP13 _WD2._ROWDRV_0.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_1.MXN11 WL5 _WD2._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_1.MXN8 _WD2._ROWDRV_1.NWL _WD2.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_1.MXP1 WL5 _WD2._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_1.MXP12 _WD2._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_1.MXP13 _WD2._ROWDRV_1.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3.I69.MX_npd _WD3.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd3.I69._nr.MXNA1 _WD3.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXNA2 _WD3.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXPA1 _WD3.ROWSEL NXP0_3 _WD3.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd3.I69._nr.MXPA2 _WD3.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_0.MXN11 WL6 _WD3._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN8 _WD3._ROWDRV_0.NWL _WD3.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_0.MXP1 WL6 _WD3._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_0.MXP12 _WD3._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_0.MXP13 _WD3._ROWDRV_0.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_1.MXN11 WL7 _WD3._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_1.MXN8 _WD3._ROWDRV_1.NWL _WD3.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_1.MXP1 WL7 _WD3._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_1.MXP12 _WD3._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_1.MXP13 _WD3._ROWDRV_1.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4.I69.MX_npd _WD4.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd4.I69._nr.MXNA1 _WD4.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXNA2 _WD4.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXPA1 _WD4.ROWSEL NXP0_4 _WD4.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd4.I69._nr.MXPA2 _WD4.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_0.MXN11 WL8 _WD4._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN8 _WD4._ROWDRV_0.NWL _WD4.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_0.MXP1 WL8 _WD4._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_0.MXP12 _WD4._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_0.MXP13 _WD4._ROWDRV_0.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_1.MXN11 WL9 _WD4._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_1.MXN8 _WD4._ROWDRV_1.NWL _WD4.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_1.MXP1 WL9 _WD4._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_1.MXP12 _WD4._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_1.MXP13 _WD4._ROWDRV_1.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5.I69.MX_npd _WD5.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd5.I69._nr.MXNA1 _WD5.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXNA2 _WD5.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXPA1 _WD5.ROWSEL NXP0_5 _WD5.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd5.I69._nr.MXPA2 _WD5.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_0.MXN11 WL10 _WD5._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN8 _WD5._ROWDRV_0.NWL _WD5.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_0.MXP1 WL10 _WD5._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_0.MXP12 _WD5._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_0.MXP13 _WD5._ROWDRV_0.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_1.MXN11 WL11 _WD5._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_1.MXN8 _WD5._ROWDRV_1.NWL _WD5.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_1.MXP1 WL11 _WD5._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_1.MXP12 _WD5._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_1.MXP13 _WD5._ROWDRV_1.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6.I69.MX_npd _WD6.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd6.I69._nr.MXNA1 _WD6.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXNA2 _WD6.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXPA1 _WD6.ROWSEL NXP0_6 _WD6.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd6.I69._nr.MXPA2 _WD6.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_0.MXN11 WL12 _WD6._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN8 _WD6._ROWDRV_0.NWL _WD6.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_0.MXP1 WL12 _WD6._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_0.MXP12 _WD6._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_0.MXP13 _WD6._ROWDRV_0.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_1.MXN11 WL13 _WD6._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_1.MXN8 _WD6._ROWDRV_1.NWL _WD6.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_1.MXP1 WL13 _WD6._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_1.MXP12 _WD6._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_1.MXP13 _WD6._ROWDRV_1.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7.I69.MX_npd _WD7.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd7.I69._nr.MXNA1 _WD7.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXNA2 _WD7.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXPA1 _WD7.ROWSEL NXP0_7 _WD7.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd7.I69._nr.MXPA2 _WD7.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_0.MXN11 WL14 _WD7._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN8 _WD7._ROWDRV_0.NWL _WD7.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_0.MXP1 WL14 _WD7._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_0.MXP12 _WD7._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_0.MXP13 _WD7._ROWDRV_0.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_1.MXN11 WL15 _WD7._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_1.MXN8 _WD7._ROWDRV_1.NWL _WD7.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_1.MXP1 WL15 _WD7._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_1.MXP12 _WD7._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_1.MXP13 _WD7._ROWDRV_1.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8.I69.MX_npd _WD8.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd8.I69._nr.MXNA1 _WD8.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXNA2 _WD8.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXPA1 _WD8.ROWSEL NXP0_0 _WD8.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd8.I69._nr.MXPA2 _WD8.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_0.MXN11 WL16 _WD8._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN8 _WD8._ROWDRV_0.NWL _WD8.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_0.MXP1 WL16 _WD8._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_0.MXP12 _WD8._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_0.MXP13 _WD8._ROWDRV_0.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_1.MXN11 WL17 _WD8._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_1.MXN8 _WD8._ROWDRV_1.NWL _WD8.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_1.MXP1 WL17 _WD8._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_1.MXP12 _WD8._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_1.MXP13 _WD8._ROWDRV_1.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9.I69.MX_npd _WD9.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd9.I69._nr.MXNA1 _WD9.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXNA2 _WD9.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXPA1 _WD9.ROWSEL NXP0_1 _WD9.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd9.I69._nr.MXPA2 _WD9.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_0.MXN11 WL18 _WD9._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN8 _WD9._ROWDRV_0.NWL _WD9.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_0.MXP1 WL18 _WD9._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_0.MXP12 _WD9._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_0.MXP13 _WD9._ROWDRV_0.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_1.MXN11 WL19 _WD9._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_1.MXN8 _WD9._ROWDRV_1.NWL _WD9.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_1.MXP1 WL19 _WD9._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_1.MXP12 _WD9._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_1.MXP13 _WD9._ROWDRV_1.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wdxtop.I69.MX_npd _WDXTOP.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA1 _WDXTOP.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA2 _WDXTOP.ROWSEL NXP1_1 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXPA1 _WDXTOP.ROWSEL NXP0_7 _WDXTOP.I69._NR.P1 VNWP
+  P11LL_CKT W=0.855U L=0.04U
X_M_wdxtop.I69._nr.MXPA2 _WDXTOP.I69._NR.P1 NXP1_1 VDDP VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wdxtop._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_0.MXN11 WL30 _WDXTOP._ROWDRV_0.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_0.MXN8 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL NI0 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_0.MXP1 WL30 _WDXTOP._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_0.MXP12 _WDXTOP._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_0.MXP13 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_wdxtop._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_1.MXN11 WL31 _WDXTOP._ROWDRV_1.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_1.MXN8 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL NI1 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_1.MXP1 WL31 _WDXTOP._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_1.MXP12 _WDXTOP._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_1.MXP13 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_xdec0._dec.I1_0.MXNA1 _XDEC0._DEC.NDEC[0] NA[0] _XDEC0._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA2 _XDEC0._DEC.I1_0.N2 NA[1] _XDEC0._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA3 _XDEC0._DEC.I1_0.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_0.MXPA1 _XDEC0._DEC.NDEC[0] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA2 _XDEC0._DEC.NDEC[0] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA3 _XDEC0._DEC.NDEC[0] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXNA1 _XDEC0._DEC.NDEC[1] IA[0] _XDEC0._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA2 _XDEC0._DEC.I1_1.N2 NA[1] _XDEC0._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA3 _XDEC0._DEC.I1_1.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_1.MXPA1 _XDEC0._DEC.NDEC[1] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA2 _XDEC0._DEC.NDEC[1] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA3 _XDEC0._DEC.NDEC[1] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXNA1 _XDEC0._DEC.NDEC[2] NA[0] _XDEC0._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA2 _XDEC0._DEC.I1_2.N2 IA[1] _XDEC0._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA3 _XDEC0._DEC.I1_2.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_2.MXPA1 _XDEC0._DEC.NDEC[2] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA2 _XDEC0._DEC.NDEC[2] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA3 _XDEC0._DEC.NDEC[2] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXNA1 _XDEC0._DEC.NDEC[3] IA[0] _XDEC0._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA2 _XDEC0._DEC.I1_3.N2 IA[1] _XDEC0._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA3 _XDEC0._DEC.I1_3.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_3.MXPA1 _XDEC0._DEC.NDEC[3] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA2 _XDEC0._DEC.NDEC[3] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA3 _XDEC0._DEC.NDEC[3] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXNA1 _XDEC0._DEC.NDEC[4] NA[0] _XDEC0._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA2 _XDEC0._DEC.I1_4.N2 NA[1] _XDEC0._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA3 _XDEC0._DEC.I1_4.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_4.MXPA1 _XDEC0._DEC.NDEC[4] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA2 _XDEC0._DEC.NDEC[4] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA3 _XDEC0._DEC.NDEC[4] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXNA1 _XDEC0._DEC.NDEC[5] IA[0] _XDEC0._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA2 _XDEC0._DEC.I1_5.N2 NA[1] _XDEC0._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA3 _XDEC0._DEC.I1_5.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_5.MXPA1 _XDEC0._DEC.NDEC[5] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA2 _XDEC0._DEC.NDEC[5] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA3 _XDEC0._DEC.NDEC[5] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXNA1 _XDEC0._DEC.NDEC[6] NA[0] _XDEC0._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA2 _XDEC0._DEC.I1_6.N2 IA[1] _XDEC0._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA3 _XDEC0._DEC.I1_6.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_6.MXPA1 _XDEC0._DEC.NDEC[6] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA2 _XDEC0._DEC.NDEC[6] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA3 _XDEC0._DEC.NDEC[6] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXNA1 _XDEC0._DEC.NDEC[7] IA[0] _XDEC0._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA2 _XDEC0._DEC.I1_7.N2 IA[1] _XDEC0._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA3 _XDEC0._DEC.I1_7.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_7.MXPA1 _XDEC0._DEC.NDEC[7] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA2 _XDEC0._DEC.NDEC[7] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA3 _XDEC0._DEC.NDEC[7] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I3_0.MXNA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_0.MXPA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_1.MXNA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_1.MXPA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_2.MXNA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_2.MXPA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_3.MXNA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_3.MXPA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_4.MXNA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_4.MXPA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_5.MXNA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_5.MXPA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_6.MXNA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_6.MXPA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._dec.I3_7.MXNA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_7.MXPA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec0._iv_nxp_0.MXNA1 NXP0_0 _XDEC0.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_0.MXPA1 NXP0_0 _XDEC0.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXNA1 NXP0_1 _XDEC0.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXPA1 NXP0_1 _XDEC0.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXNA1 NXP0_2 _XDEC0.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXPA1 NXP0_2 _XDEC0.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXNA1 NXP0_3 _XDEC0.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXPA1 NXP0_3 _XDEC0.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXNA1 NXP0_4 _XDEC0.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXPA1 NXP0_4 _XDEC0.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXNA1 NXP0_5 _XDEC0.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXPA1 NXP0_5 _XDEC0.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXNA1 NXP0_6 _XDEC0.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXPA1 NXP0_6 _XDEC0.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXNA1 NXP0_7 _XDEC0.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXPA1 NXP0_7 _XDEC0.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXNA1 _XDEC1._DEC.NDEC[0] NA[3] _XDEC1._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA2 _XDEC1._DEC.I1_0.N2 NA[4] _XDEC1._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA3 _XDEC1._DEC.I1_0.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXPA1 _XDEC1._DEC.NDEC[0] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA2 _XDEC1._DEC.NDEC[0] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA3 _XDEC1._DEC.NDEC[0] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXNA1 _XDEC1._DEC.NDEC[1] IA[3] _XDEC1._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA2 _XDEC1._DEC.I1_1.N2 NA[4] _XDEC1._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA3 _XDEC1._DEC.I1_1.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_1.MXPA1 _XDEC1._DEC.NDEC[1] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA2 _XDEC1._DEC.NDEC[1] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA3 _XDEC1._DEC.NDEC[1] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXNA1 _XDEC1._DEC.NDEC[2] NA[3] _XDEC1._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA2 _XDEC1._DEC.I1_2.N2 IA[4] _XDEC1._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA3 _XDEC1._DEC.I1_2.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_2.MXPA1 _XDEC1._DEC.NDEC[2] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA2 _XDEC1._DEC.NDEC[2] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA3 _XDEC1._DEC.NDEC[2] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXNA1 _XDEC1._DEC.NDEC[3] IA[3] _XDEC1._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA2 _XDEC1._DEC.I1_3.N2 IA[4] _XDEC1._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA3 _XDEC1._DEC.I1_3.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_3.MXPA1 _XDEC1._DEC.NDEC[3] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA2 _XDEC1._DEC.NDEC[3] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA3 _XDEC1._DEC.NDEC[3] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXNA1 _XDEC1._DEC.NDEC[4] NA[3] _XDEC1._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA2 _XDEC1._DEC.I1_4.N2 NA[4] _XDEC1._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA3 _XDEC1._DEC.I1_4.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_4.MXPA1 _XDEC1._DEC.NDEC[4] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA2 _XDEC1._DEC.NDEC[4] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA3 _XDEC1._DEC.NDEC[4] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXNA1 _XDEC1._DEC.NDEC[5] IA[3] _XDEC1._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA2 _XDEC1._DEC.I1_5.N2 NA[4] _XDEC1._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA3 _XDEC1._DEC.I1_5.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_5.MXPA1 _XDEC1._DEC.NDEC[5] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA2 _XDEC1._DEC.NDEC[5] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA3 _XDEC1._DEC.NDEC[5] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXNA1 _XDEC1._DEC.NDEC[6] NA[3] _XDEC1._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA2 _XDEC1._DEC.I1_6.N2 IA[4] _XDEC1._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA3 _XDEC1._DEC.I1_6.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_6.MXPA1 _XDEC1._DEC.NDEC[6] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA2 _XDEC1._DEC.NDEC[6] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA3 _XDEC1._DEC.NDEC[6] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXNA1 _XDEC1._DEC.NDEC[7] IA[3] _XDEC1._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA2 _XDEC1._DEC.I1_7.N2 IA[4] _XDEC1._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA3 _XDEC1._DEC.I1_7.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_7.MXPA1 _XDEC1._DEC.NDEC[7] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA2 _XDEC1._DEC.NDEC[7] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA3 _XDEC1._DEC.NDEC[7] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I3_0.MXNA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_0.MXPA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_1.MXNA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_1.MXPA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_2.MXNA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_2.MXPA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_3.MXNA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_3.MXPA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_4.MXNA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_4.MXPA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_5.MXNA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_5.MXPA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_6.MXNA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_6.MXPA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._dec.I3_7.MXNA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_7.MXPA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_xdec1._iv_nxp_0.MXNA1 NXP1_0 _XDEC1.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_0.MXPA1 NXP1_0 _XDEC1.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXNA1 NXP1_1 _XDEC1.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXPA1 NXP1_1 _XDEC1.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXNA1 NXP1_2 _XDEC1.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXPA1 NXP1_2 _XDEC1.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXNA1 NXP1_3 _XDEC1.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXPA1 NXP1_3 _XDEC1.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXNA1 NXP1_4 _XDEC1.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXPA1 NXP1_4 _XDEC1.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXNA1 NXP1_5 _XDEC1.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXPA1 NXP1_5 _XDEC1.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXNA1 NXP1_6 _XDEC1.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXPA1 NXP1_6 _XDEC1.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXNA1 NXP1_7 _XDEC1.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXPA1 NXP1_7 _XDEC1.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
.ENDS RAMSP128X16WDX32
****
.SUBCKT RAMSP128X16WDX2 ACTP DBL G0 G1 INI0 INI1 LOG0_DWL NACTC NI0 NI1 NI2
+  NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5
+  NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RCLK0
+  RCLK1 RET ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDCE VDDC_L VDDC_R VDDP VDDPE VNWC VNWP VPW VSS VSSE WL0 WL1
** RAMSP128X16WDX2: 20 flat devices **
X_M_dbl_load.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.425U L=0.04U
X_M_dbl_load.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.425U L=0.04U
X_M_wdx2.I69.MX_npd _WDX2.ROWSEL RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69.MX_nr_header VDDP RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wdx2.I69._nr.MXNA1 _WDX2.ROWSEL G0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69._nr.MXNA2 _WDX2.ROWSEL G1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69._nr.MXPA1 _WDX2.ROWSEL G0 _WDX2.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wdx2.I69._nr.MXPA2 _WDX2.I69._NR.P1 G1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXN10 INI0 RCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdx2._rowdrv_0.MXN11 WL0 _WDX2._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXN8 _WDX2._ROWDRV_0.NWL _WDX2.ROWSEL INI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wdx2._rowdrv_0.MXP1 WL0 _WDX2._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXP12 _WDX2._ROWDRV_0.NWL RCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdx2._rowdrv_0.MXP13 _WDX2._ROWDRV_0.NWL _WDX2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wdx2._rowdrv_1.MXN10 INI1 RCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdx2._rowdrv_1.MXN11 WL1 _WDX2._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wdx2._rowdrv_1.MXN8 _WDX2._ROWDRV_1.NWL _WDX2.ROWSEL INI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wdx2._rowdrv_1.MXP1 WL1 _WDX2._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wdx2._rowdrv_1.MXP12 _WDX2._ROWDRV_1.NWL RCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdx2._rowdrv_1.MXP13 _WDX2._ROWDRV_1.NWL _WDX2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
.ENDS RAMSP128X16WDX2
****
.SUBCKT RAMSP128X16WDDRVCOL ACTP A[0] A[1] A[2] A[3] A[4] A[5] DBL DWL EMA0
+  EMA1 EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1
+  NACTC NACT_CC NGWE NRETNVT RET_0 RET_1 SAE_DUMMY VDDC_LEFT VDDC_RIGHT
+  VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5
+  WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL0_15 WL0_16
+  WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11
+  WL1_12 WL1_13 WL1_14 WL1_15 WL1_16 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10
+  WL11 WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25
+  WL26 WL27 WL28 WL29 WL30 WL31
** RAMSP128X16WDDRVCOL: 901 flat devices **
XWD_BOT ACTP A[0] A[1] A[2] A[3] A[4] A[5] DBL RET_0 DWL EMA0 EMA1 EMA2
+  GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC
+  NGWE NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3
+  NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5
+  NXP1_6 NXP1_7 RET_1 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6
+  ROWCLK7 SAE_DUMMY VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE
+  VSSE WL0_0 WL1_0 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11 WL12 WL13 WL14
+  WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26 WL27 WL28 WL29
+  WL30 WL31 RAMSP128X16WDX32
XWD_I0 ACTP DBL NXP0_0 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_1 WL1_1
+  RAMSP128X16WDX2
XWD_I1 ACTP DBL NXP0_1 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_2 WL1_2
+  RAMSP128X16WDX2
XWD_I10 ACTP DBL NXP0_2 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_11 WL1_11
+  RAMSP128X16WDX2
XWD_I11 ACTP DBL NXP0_3 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_12 WL1_12
+  RAMSP128X16WDX2
XWD_I12 ACTP DBL NXP0_4 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_13 WL1_13
+  RAMSP128X16WDX2
XWD_I13 ACTP DBL NXP0_5 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_14 WL1_14
+  RAMSP128X16WDX2
XWD_I14 ACTP DBL NXP0_6 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_15 WL1_15
+  RAMSP128X16WDX2
XWD_I2 ACTP DBL NXP0_2 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_3 WL1_3
+  RAMSP128X16WDX2
XWD_I3 ACTP DBL NXP0_3 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_4 WL1_4
+  RAMSP128X16WDX2
XWD_I4 ACTP DBL NXP0_4 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_5 WL1_5
+  RAMSP128X16WDX2
XWD_I5 ACTP DBL NXP0_5 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_6 WL1_6
+  RAMSP128X16WDX2
XWD_I6 ACTP DBL NXP0_6 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_7 WL1_7
+  RAMSP128X16WDX2
XWD_I7 ACTP DBL NXP0_7 NXP1_2 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_8 WL1_8
+  RAMSP128X16WDX2
XWD_I8 ACTP DBL NXP0_0 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_9 WL1_9
+  RAMSP128X16WDX2
XWD_I9 ACTP DBL NXP0_1 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_10 WL1_10
+  RAMSP128X16WDX2
XWD_TOP ACTP DBL NXP0_7 NXP1_3 NI0 NI1 LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDC_WL VDDC_WL VDDC_WL VDDP VDDPE VNWC VNWP VPW VSSE VSSE WL0_16 WL1_16
+  RAMSP128X16WDX2
XWL_CAP ACTP DBL LOG0_DWL NACTC NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0
+  NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2
+  NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3
+  ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VDDC_WL VDDC_LEFT VDDC_RIGHT VDDC_WL VDDP
+  VDDPE VNWC VNWP VPW VSSE VSSE RAMSP128X16WDTOP
.ENDS RAMSP128X16WDDRVCOL
****
.SUBCKT RAMSP128X16MEM_SLICE ACTP A[0] A[1] A[2] A[3] A[4] A[5] BL[0]_0
+  BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2
+  BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3
+  BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 DBL DWL EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NGWE NRETNVT
+  RET_0 RET_1 SAE_DUMMY VDDC_0 VDDC_1 VDDC_WL VDDP VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VNWC VNWP_0 VNWP_1 VNWP_2
+  VNWP_3 VNWP_4 VPW_0 VPW_1
** RAMSP128X16MEM_SLICE: 13713 flat devices **
XMEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 VDDC_0
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWP_0 VNWP_1 VPW_0 WL[0]_0 WL[0]_1 WL[0]_2
+  WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11
+  WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19
+  WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27
+  WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4
+  WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13
+  WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21
+  WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29
+  WL[1]_30 WL[1]_31 RAMSP128X16MEMCORE_L
XMEMCORE_R BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_4
+  NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_4
+  NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC_1
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VNWP_3 VNWP_4 VPW_0 WL[0]_0 WL[0]_1 WL[0]_2
+  WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11
+  WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19
+  WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27
+  WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4
+  WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13
+  WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21
+  WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29
+  WL[1]_30 WL[1]_31 RAMSP128X16MEMCORE_R
XWDDRVCOL ACTP A[0] A[1] A[2] A[3] A[4] A[5] DBL DWL EMA0 EMA1 EMA2 GTPCLK0
+  GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE
+  NRETNVT RET_0 RET_1 SAE_DUMMY VDDC_0 VDDC_1 VDDC_WL VDDP VDDPE_4 VNWC
+  VNWP_2 VPW_1 VPW_0 WL[0]_0 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20
+  WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28
+  WL[0]_29 WL[0]_30 WL[0]_31 WL[1]_0 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19
+  WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27
+  WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[0]_1 WL[1]_1 WL[0]_2 WL[1]_2 WL[0]_3
+  WL[1]_3 WL[0]_4 WL[1]_4 WL[0]_5 WL[1]_5 WL[0]_6 WL[1]_6 WL[0]_7 WL[1]_7
+  WL[0]_8 WL[1]_8 WL[0]_9 WL[1]_9 WL[0]_10 WL[1]_10 WL[0]_11 WL[1]_11
+  WL[0]_12 WL[1]_12 WL[0]_13 WL[1]_13 WL[0]_14 WL[1]_14 WL[0]_15 WL[1]_15
+  RAMSP128X16WDDRVCOL
.ENDS RAMSP128X16MEM_SLICE
****
.SUBCKT RAMSP128X16TILE_TOP CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2
+  D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6
+  D1_7 DFTRAMBYP EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3
+  FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN
+  GWENY LA0 LA2 LAY0 LAY1 LAY2 PEN PENSI PENSO PSO0 PSO1 Q0_0 Q0_1 Q0_2 Q0_3
+  Q0_4 Q0_5 Q0_6 Q0_7 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 RA0 RA1 RA2 RA3
+  RA4 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RET1N SO0 SO1 TCA1 TCA2 TEN TLA2 TPEN
+  VDDC_L VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7
+  WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WENY0_0 WENY0_1
+  WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1 WENY1_2
+  WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7
** RAMSP128X16TILE_TOP: 16970 flat devices **
XBOTCAP CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 DFTRAMBYP
+  DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 DFTRAMBYP LA2 LAY0 LAY1 LAY2 DFTRAMBYP
+  NWCLK PEN PENSI PENSO DFTRAMBYP DFTRAMBYP PSO0 PSO1 Q0_0 Q0_1 Q0_2 Q0_3
+  Q0_4 Q0_5 Q0_6 Q0_7 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 RA0 RA1 RA2 RA3
+  RA4 DFTRAMBYP RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 DFTRAMBYP RET1N DFTRAMBYP SEL_D
+  SEL_SI SEL_TD DFTRAMBYP DFTRAMBYP SO0 SO1 DFTRAMBYP TCA1 TCA2 DFTRAMBYP TEN
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP TLA2 TPEN DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDPE VDDPE VDDC_L VDDC_L VDDC_L VDDPE
+  VPW VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1 WENY1_2 WENY1_3
+  WENY1_4 WENY1_5 WENY1_6 WENY1_7 RAMSP128X16BOTCAPROW
XIO_SLICE DUM_ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 CA0 CA1 CA2 CAY0
+  CAY1 CAY2 CEN CENY CLK CRE1 CRE2 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7
+  D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 DBL RET DUMMY_DWL_R PEN PENSI PENSO
+  PSO0 PSO1 TPEN DWL EMAW0 EMAW1 EMA0 EMA1 EMA2 FCA1_0 FCA1_1 FCA1_2 FCA1_3
+  FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP
+  GWEN GWENY LA0 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP LOG0_DWL TEN DUM_NACTC NACT_CC NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NGWE DUM_RETNVT NWCLK
+  Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6
+  Q1_7 RA0 RA1 RA2 RA3 RA4 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1]
+  RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RET_75 RET1N SAE_DUMMY SEL_D SEL_SI
+  SEL_TD SO0 SO1 TCA1 TCA2 DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP TLA2 DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP VDDC_L VDDP
+  VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1 WENY1_2 WENY1_3
+  WENY1_4 WENY1_5 WENY1_6 WENY1_7 RAMSP128X16IO_SLICE
XMEMSLICE DUM_ACTP RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5]
+  BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0
+  BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2
+  BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 DBL DWL EMA0 EMA1 EMA2 GTP GTP
+  LA_P2[0] LA_P2[1] LA_P2[2] DFTRAMBYP LOG0_DWL TEN DUM_NACTC NACT_CC
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NGWE DUM_RETNVT RET RET_75 SAE_DUMMY VDDC_L VDDC_L VDDC_L VDDP VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDC_L VDDPE VDDPE VDDPE VDDPE
+  VDDPE VPW VPW RAMSP128X16MEM_SLICE
.ENDS RAMSP128X16TILE_TOP
****
.SUBCKT RAMSP128X16 VDDCE VDDPE VSSE Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9]
+  Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN WEN[15] WEN[14]
+  WEN[13] WEN[12] WEN[11] WEN[10] WEN[9] WEN[8] WEN[7] WEN[6] WEN[5] WEN[4]
+  WEN[3] WEN[2] WEN[1] WEN[0] A[6] A[5] A[4] A[3] A[2] A[1] A[0] D[15] D[14]
+  D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0]
+  EMA[2] EMA[1] EMA[0] EMAW[1] EMAW[0] GWEN RET1N
** RAMSP128X16: 16970 flat devices **
XI0 A[0] CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 D[1] D[3] D[5] D[7]
+  D[8] D[10] D[12] D[14] D[0] D[2] D[4] D[6] D[9] D[11] D[13] D[15] DFTRAMBYP
+  EMA[0] EMA[1] EMA[2] EMAW[0] EMAW[1] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4
+  FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY
+  A[1] LA2 LAY0 LAY1 LAY2 PEN PENSI PENSO PSO0 PSO1 Q[1] Q[3] Q[5] Q[7] Q[8]
+  Q[10] Q[12] Q[14] Q[0] Q[2] Q[4] Q[6] Q[9] Q[11] Q[13] Q[15] A[2] A[3] A[4]
+  A[5] A[6] RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RET1N SO0 SO1 TCA1 TCA2 TEN TLA2
+  TPEN VDDCE VDDPE VSSE WEN[1] WEN[3] WEN[5] WEN[7] WEN[8] WEN[10] WEN[12]
+  WEN[14] WEN[0] WEN[2] WEN[4] WEN[6] WEN[9] WEN[11] WEN[13] WEN[15] WENY0_0
+  WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 RAMSP128X16TILE_TOP
.ENDS RAMSP128X16
