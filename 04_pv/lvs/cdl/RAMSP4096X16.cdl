+  ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 SAE_DUMMY VDDCE VDDC_L VDDC_R VDDP VDDPE
+  VNWC VNWP VPW VSS VSSE WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11
+  WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26
+  WL27 WL28 WL29 WL30 WL31 WL32 WL33 WL34 WL35 WL36 WL37 WL38 WL39 WL40 WL41
+  WL42 WL43 WL44 WL45 WL46 WL47 WL48 WL49 WL50 WL51 WL52 WL53 WL54 WL55 WL56
+  WL57 WL58 WL59 WL60 WL61 WL62 WL63
** RAMSP4096X16WDX64: 1066 flat devices **
X_MI46_0.MXNA1 IA[0] NA[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_0.MXPA1 IA[0] NA[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI46_1.MXNA1 IA[1] NA[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_1.MXPA1 IA[1] NA[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI46_2.MXNA1 IA[2] NA[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_2.MXPA1 IA[2] NA[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_0.MXNA1 NA[0] A[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_0.MXPA1 NA[0] A[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_1.MXNA1 NA[1] A[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_1.MXPA1 NA[1] A[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_2.MXNA1 NA[2] A[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_2.MXPA1 NA[2] A[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI48.MXN0 IZERO I48.NODEB VSSE VPW N11LL_CKT W=0.51U L=0.04U
X_MI48.MXN1 I48.NODEA I48.NODEA VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXN2 I48.NODEA I48.NODEB VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXP1 I48.NODEB I48.NODEA VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_MI48.MXP4 IONE I48.NODEA VDDPE VNWP P11LL_CKT W=1.04U L=0.04U
X_MI53.MXNA1 NACT_CC ACT_CC VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_MI53.MXPA1 NACT_CC ACT_CC VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MI54.MXNA1 ACT_CC RET VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MI54.MXPA1 ACT_CC RET VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI56.I69.MX_npd I56.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI56.I69._nr.MXNA1 I56.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69._nr.MXNA2 I56.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69._nr.MXPA1 I56.ROWSEL NXP0_5 I56.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI56.I69._nr.MXPA2 I56.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI56._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI56._rowdrv_0.MXN11 WL40 I56._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI56._rowdrv_0.MXN8 I56._ROWDRV_0.NWL I56.ROWSEL NI0 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI56._rowdrv_0.MXP1 WL40 I56._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI56._rowdrv_0.MXP12 I56._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI56._rowdrv_0.MXP13 I56._ROWDRV_0.NWL I56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI56._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI56._rowdrv_1.MXN11 WL41 I56._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI56._rowdrv_1.MXN8 I56._ROWDRV_1.NWL I56.ROWSEL NI1 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI56._rowdrv_1.MXP1 WL41 I56._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI56._rowdrv_1.MXP12 I56._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI56._rowdrv_1.MXP13 I56._ROWDRV_1.NWL I56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI57.I69.MX_npd I57.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI57.I69._nr.MXNA1 I57.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69._nr.MXNA2 I57.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69._nr.MXPA1 I57.ROWSEL NXP0_5 I57.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI57.I69._nr.MXPA2 I57.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI57._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI57._rowdrv_0.MXN11 WL42 I57._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI57._rowdrv_0.MXN8 I57._ROWDRV_0.NWL I57.ROWSEL NI2 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI57._rowdrv_0.MXP1 WL42 I57._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI57._rowdrv_0.MXP12 I57._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI57._rowdrv_0.MXP13 I57._ROWDRV_0.NWL I57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI57._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI57._rowdrv_1.MXN11 WL43 I57._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI57._rowdrv_1.MXN8 I57._ROWDRV_1.NWL I57.ROWSEL NI3 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI57._rowdrv_1.MXP1 WL43 I57._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI57._rowdrv_1.MXP12 I57._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI57._rowdrv_1.MXP13 I57._ROWDRV_1.NWL I57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI60.I69.MX_npd I60.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI60.I69._nr.MXNA1 I60.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69._nr.MXNA2 I60.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69._nr.MXPA1 I60.ROWSEL NXP0_4 I60.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI60.I69._nr.MXPA2 I60.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI60._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI60._rowdrv_0.MXN11 WL36 I60._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI60._rowdrv_0.MXN8 I60._ROWDRV_0.NWL I60.ROWSEL NI4 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI60._rowdrv_0.MXP1 WL36 I60._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI60._rowdrv_0.MXP12 I60._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI60._rowdrv_0.MXP13 I60._ROWDRV_0.NWL I60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI60._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI60._rowdrv_1.MXN11 WL37 I60._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI60._rowdrv_1.MXN8 I60._ROWDRV_1.NWL I60.ROWSEL NI5 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI60._rowdrv_1.MXP1 WL37 I60._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI60._rowdrv_1.MXP12 I60._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI60._rowdrv_1.MXP13 I60._ROWDRV_1.NWL I60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI61.I69.MX_npd I61.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI61.I69._nr.MXNA1 I61.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69._nr.MXNA2 I61.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69._nr.MXPA1 I61.ROWSEL NXP0_4 I61.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI61.I69._nr.MXPA2 I61.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI61._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI61._rowdrv_0.MXN11 WL38 I61._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI61._rowdrv_0.MXN8 I61._ROWDRV_0.NWL I61.ROWSEL NI6 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI61._rowdrv_0.MXP1 WL38 I61._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI61._rowdrv_0.MXP12 I61._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI61._rowdrv_0.MXP13 I61._ROWDRV_0.NWL I61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI61._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI61._rowdrv_1.MXN11 WL39 I61._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI61._rowdrv_1.MXN8 I61._ROWDRV_1.NWL I61.ROWSEL NI7 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI61._rowdrv_1.MXP1 WL39 I61._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI61._rowdrv_1.MXP12 I61._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI61._rowdrv_1.MXP13 I61._ROWDRV_1.NWL I61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI62.I69.MX_npd I62.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI62.I69._nr.MXNA1 I62.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69._nr.MXNA2 I62.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69._nr.MXPA1 I62.ROWSEL NXP0_4 I62.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI62.I69._nr.MXPA2 I62.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI62._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI62._rowdrv_0.MXN11 WL34 I62._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI62._rowdrv_0.MXN8 I62._ROWDRV_0.NWL I62.ROWSEL NI2 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI62._rowdrv_0.MXP1 WL34 I62._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI62._rowdrv_0.MXP12 I62._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI62._rowdrv_0.MXP13 I62._ROWDRV_0.NWL I62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI62._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI62._rowdrv_1.MXN11 WL35 I62._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI62._rowdrv_1.MXN8 I62._ROWDRV_1.NWL I62.ROWSEL NI3 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI62._rowdrv_1.MXP1 WL35 I62._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI62._rowdrv_1.MXP12 I62._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI62._rowdrv_1.MXP13 I62._ROWDRV_1.NWL I62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI63.I69.MX_npd I63.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI63.I69._nr.MXNA1 I63.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69._nr.MXNA2 I63.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69._nr.MXPA1 I63.ROWSEL NXP0_4 I63.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI63.I69._nr.MXPA2 I63.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI63._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI63._rowdrv_0.MXN11 WL32 I63._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI63._rowdrv_0.MXN8 I63._ROWDRV_0.NWL I63.ROWSEL NI0 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI63._rowdrv_0.MXP1 WL32 I63._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI63._rowdrv_0.MXP12 I63._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI63._rowdrv_0.MXP13 I63._ROWDRV_0.NWL I63.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI63._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI63._rowdrv_1.MXN11 WL33 I63._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI63._rowdrv_1.MXN8 I63._ROWDRV_1.NWL I63.ROWSEL NI1 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI63._rowdrv_1.MXP1 WL33 I63._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI63._rowdrv_1.MXP12 I63._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI63._rowdrv_1.MXP13 I63._ROWDRV_1.NWL I63.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI78.I1_0.MXNA1 I78.NDEC[0] NLA_P2[0] I78.I1_0.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_0.MXNA2 I78.I1_0.N2 NLA_P2[1] I78.I1_0.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_0.MXNA3 I78.I1_0.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA1 I78.NDEC[0] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA2 I78.NDEC[0] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA3 I78.NDEC[0] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXNA1 I78.NDEC[1] LA_P2[0] I78.I1_1.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_1.MXNA2 I78.I1_1.N2 NLA_P2[1] I78.I1_1.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_1.MXNA3 I78.I1_1.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA1 I78.NDEC[1] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA2 I78.NDEC[1] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA3 I78.NDEC[1] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXNA1 I78.NDEC[2] NLA_P2[0] I78.I1_2.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_2.MXNA2 I78.I1_2.N2 LA_P2[1] I78.I1_2.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_2.MXNA3 I78.I1_2.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA1 I78.NDEC[2] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA2 I78.NDEC[2] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA3 I78.NDEC[2] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXNA1 I78.NDEC[3] LA_P2[0] I78.I1_3.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_3.MXNA2 I78.I1_3.N2 LA_P2[1] I78.I1_3.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_3.MXNA3 I78.I1_3.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA1 I78.NDEC[3] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA2 I78.NDEC[3] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA3 I78.NDEC[3] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXNA1 I78.NDEC[4] NLA_P2[0] I78.I1_4.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_4.MXNA2 I78.I1_4.N2 NLA_P2[1] I78.I1_4.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_4.MXNA3 I78.I1_4.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA1 I78.NDEC[4] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA2 I78.NDEC[4] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA3 I78.NDEC[4] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXNA1 I78.NDEC[5] LA_P2[0] I78.I1_5.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_5.MXNA2 I78.I1_5.N2 NLA_P2[1] I78.I1_5.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_5.MXNA3 I78.I1_5.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA1 I78.NDEC[5] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA2 I78.NDEC[5] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA3 I78.NDEC[5] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXNA1 I78.NDEC[6] NLA_P2[0] I78.I1_6.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_6.MXNA2 I78.I1_6.N2 LA_P2[1] I78.I1_6.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_6.MXNA3 I78.I1_6.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA1 I78.NDEC[6] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA2 I78.NDEC[6] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA3 I78.NDEC[6] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXNA1 I78.NDEC[7] LA_P2[0] I78.I1_7.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_7.MXNA2 I78.I1_7.N2 LA_P2[1] I78.I1_7.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_7.MXNA3 I78.I1_7.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA1 I78.NDEC[7] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA2 I78.NDEC[7] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA3 I78.NDEC[7] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I3_0.MXNA1 XROW[0] I78.NDEC[0] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_0.MXPA1 XROW[0] I78.NDEC[0] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_1.MXNA1 XROW[1] I78.NDEC[1] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_1.MXPA1 XROW[1] I78.NDEC[1] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_2.MXNA1 XROW[2] I78.NDEC[2] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_2.MXPA1 XROW[2] I78.NDEC[2] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_3.MXNA1 XROW[3] I78.NDEC[3] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_3.MXPA1 XROW[3] I78.NDEC[3] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_4.MXNA1 XROW[4] I78.NDEC[4] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_4.MXPA1 XROW[4] I78.NDEC[4] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_5.MXNA1 XROW[5] I78.NDEC[5] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_5.MXPA1 XROW[5] I78.NDEC[5] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_6.MXNA1 XROW[6] I78.NDEC[6] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_6.MXPA1 XROW[6] I78.NDEC[6] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_7.MXNA1 XROW[7] I78.NDEC[7] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_7.MXPA1 XROW[7] I78.NDEC[7] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI79.MXNA1 NLA_P2[1] LA_P2[1] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI79.MXPA1 NLA_P2[1] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI80.MXNA1 NLA_P2[0] LA_P2[0] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI80.MXPA1 NLA_P2[0] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI81.MXNA1 NLA_P2[2] LA_P2[2] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI81.MXPA1 NLA_P2[2] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_3.MXNA1 IA[3] NA[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_3.MXPA1 IA[3] NA[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_4.MXNA1 IA[4] NA[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_4.MXPA1 IA[4] NA[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_5.MXNA1 IA[5] NA[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_5.MXPA1 IA[5] NA[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_3.MXNA1 NA[3] A[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_3.MXPA1 NA[3] A[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_4.MXNA1 NA[4] A[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_4.MXPA1 NA[4] A[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_5.MXNA1 NA[5] A[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_5.MXPA1 NA[5] A[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MXN1 VSS DBL VSS VPW N11LL_CKT W=2.85U L=0.04U
X_MXN5 LOG0 IONE VSSE VPW N11LL_CKT W=3.98U L=0.04U
X_MXN7 LOG0_DWL IONE VSSE VPW N11LL_CKT W=2.84U L=0.04U
X_MXP3 VDDPE DBL VDDPE VNWP P11LL_CKT W=3.55U L=0.04U
X_MXP4 LOG1 IZERO VDDPE VNWP P11LL_CKT W=5.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXNA1 SAE_DUMMY DBL VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXPA1 SAE_DUMMY DBL VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cmuxsa_dummy.MXN0 VSS DBL VSS VPW N11LL_CKT W=1.875U L=0.085U
X_M_cmuxsa_dummy.MXN1 VSS DBL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cmuxsa_dummy.MXN4_0 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXN4_1 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXP1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP2 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cmuxsa_dummy.MXP3 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_dbl_load_0.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_0.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_16.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_16.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_17.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_17.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_18.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_18.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_19.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_19.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_20.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_20.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_21.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_21.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_22.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_22.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_23.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_23.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_24.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_24.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_25.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_25.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_26.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_26.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_27.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_27.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_28.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_28.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_29.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_29.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_30.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_30.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_31.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_31.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_32.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_32.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_33.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_33.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_34.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_34.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_35.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_35.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_36.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_36.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_37.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_37.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_38.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_38.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_39.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_39.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_40.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_40.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_41.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_41.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_42.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_42.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_43.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_43.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_44.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_44.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_45.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_45.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_46.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_46.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_47.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_47.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_48.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_48.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_49.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_49.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_50.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_50.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_51.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_51.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_52.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_52.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_53.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_53.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_54.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_54.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_55.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_55.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_56.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_56.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_57.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_57.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_58.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_58.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_59.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_59.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_60.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_60.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_61.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_61.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dummy.I81.MXNA1 _DUMMY.NSEL0 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I81.MXNA2 _DUMMY.NSEL0 EMA0 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I81.MXPA1 _DUMMY.NSEL0 EMA2 _DUMMY.I81.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I81.MXPA2 _DUMMY.I81.P1 EMA0 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.I82.MXNA1 _DUMMY.NSEL1 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I82.MXNA2 _DUMMY.NSEL1 EMA1 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I82.MXPA1 _DUMMY.NSEL1 EMA2 _DUMMY.I82.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I82.MXPA2 _DUMMY.I82.P1 EMA1 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.I83.MXNA1 _DUMMY.NIDBL DBL VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I83.MXPA1 _DUMMY.NIDBL DBL VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_dummy.MXN34 I[2] LOG1 VSSE VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN35 DBL DWL _DUMMY.IA[1] VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXN36 DBL DWL _DUMMY.IA[0] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN37 DBL DWL _DUMMY.IA[3] VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN38 VSSE LOG1 VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN39 _DUMMY.IA[2] _DUMMY.NSEL1 I[2] VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN40 _DUMMY.IA[1] _DUMMY.NSEL0 I[1] VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXN41 _DUMMY.IA[3] LOG1 VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN42 DBL DWL _DUMMY.IA[4] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN43 I[4] LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN44 _DUMMY.IA[4] LOG1 I[4] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN45 _DUMMY.IA[0] LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN46 DBL DWL _DUMMY.IA[2] VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN47 VSSE LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN48 I[1] LOG1 VSSE VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXP13 DBL LOG1 _DUMMY.NET60 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.MXP14 DBL DWL VDDPE VNWP P11LL_CKT W=3.55U L=0.04U
X_M_dummy.MXP15 _DUMMY.NET60 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP16 _DUMMY.NET68 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP17 DBL LOG1 _DUMMY.NET68 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_rowdrv_0.I2.MXNA1 _ROWDRV_0.NROWCLK GTPCLK0 _ROWDRV_0.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_0.I2.MXNA2 _ROWDRV_0.I2.N1 XROW[0] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA1 _ROWDRV_0.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA2 _ROWDRV_0.NROWCLK XROW[0] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXNA1 ROWCLK0 _ROWDRV_0.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXPA1 ROWCLK0 _ROWDRV_0.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_0.MXN0 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_1.I2.MXNA1 _ROWDRV_1.NROWCLK GTPCLK1 _ROWDRV_1.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_1.I2.MXNA2 _ROWDRV_1.I2.N1 XROW[1] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA1 _ROWDRV_1.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA2 _ROWDRV_1.NROWCLK XROW[1] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXNA1 ROWCLK1 _ROWDRV_1.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXPA1 ROWCLK1 _ROWDRV_1.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_1.MXN0 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_2.I2.MXNA1 _ROWDRV_2.NROWCLK GTPCLK0 _ROWDRV_2.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_2.I2.MXNA2 _ROWDRV_2.I2.N1 XROW[2] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_2.I2.MXPA1 _ROWDRV_2.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_2.I2.MXPA2 _ROWDRV_2.NROWCLK XROW[2] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_2.IV_RdWrClk.MXNA1 ROWCLK2 _ROWDRV_2.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_2.IV_RdWrClk.MXPA1 ROWCLK2 _ROWDRV_2.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_2.MXN0 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_3.I2.MXNA1 _ROWDRV_3.NROWCLK GTPCLK1 _ROWDRV_3.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_3.I2.MXNA2 _ROWDRV_3.I2.N1 XROW[3] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_3.I2.MXPA1 _ROWDRV_3.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_3.I2.MXPA2 _ROWDRV_3.NROWCLK XROW[3] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_3.IV_RdWrClk.MXNA1 ROWCLK3 _ROWDRV_3.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_3.IV_RdWrClk.MXPA1 ROWCLK3 _ROWDRV_3.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_3.MXN0 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_4.I2.MXNA1 _ROWDRV_4.NROWCLK GTPCLK0 _ROWDRV_4.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_4.I2.MXNA2 _ROWDRV_4.I2.N1 XROW[4] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_4.I2.MXPA1 _ROWDRV_4.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_4.I2.MXPA2 _ROWDRV_4.NROWCLK XROW[4] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_4.IV_RdWrClk.MXNA1 ROWCLK4 _ROWDRV_4.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_4.IV_RdWrClk.MXPA1 ROWCLK4 _ROWDRV_4.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_4.MXN0 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_5.I2.MXNA1 _ROWDRV_5.NROWCLK GTPCLK1 _ROWDRV_5.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_5.I2.MXNA2 _ROWDRV_5.I2.N1 XROW[5] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_5.I2.MXPA1 _ROWDRV_5.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_5.I2.MXPA2 _ROWDRV_5.NROWCLK XROW[5] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_5.IV_RdWrClk.MXNA1 ROWCLK5 _ROWDRV_5.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_5.IV_RdWrClk.MXPA1 ROWCLK5 _ROWDRV_5.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_5.MXN0 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_6.I2.MXNA1 _ROWDRV_6.NROWCLK GTPCLK0 _ROWDRV_6.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_6.I2.MXNA2 _ROWDRV_6.I2.N1 XROW[6] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_6.I2.MXPA1 _ROWDRV_6.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_6.I2.MXPA2 _ROWDRV_6.NROWCLK XROW[6] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_6.IV_RdWrClk.MXNA1 ROWCLK6 _ROWDRV_6.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_6.IV_RdWrClk.MXPA1 ROWCLK6 _ROWDRV_6.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_6.MXN0 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_7.I2.MXNA1 _ROWDRV_7.NROWCLK GTPCLK1 _ROWDRV_7.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_7.I2.MXNA2 _ROWDRV_7.I2.N1 XROW[7] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_7.I2.MXPA1 _ROWDRV_7.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_7.I2.MXPA2 _ROWDRV_7.NROWCLK XROW[7] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_7.IV_RdWrClk.MXNA1 ROWCLK7 _ROWDRV_7.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_7.IV_RdWrClk.MXPA1 ROWCLK7 _ROWDRV_7.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_7.MXN0 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wd0.I69.MX_npd _WD0.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd0.I69._nr.MXNA1 _WD0.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXNA2 _WD0.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXPA1 _WD0.ROWSEL NXP0_0 _WD0.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd0.I69._nr.MXPA2 _WD0.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_0.MXN11 WL0 _WD0._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN8 _WD0._ROWDRV_0.NWL _WD0.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_0.MXP1 WL0 _WD0._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_0.MXP12 _WD0._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_0.MXP13 _WD0._ROWDRV_0.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd0._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_1.MXN11 WL1 _WD0._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_1.MXN8 _WD0._ROWDRV_1.NWL _WD0.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_1.MXP1 WL1 _WD0._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_1.MXP12 _WD0._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_1.MXP13 _WD0._ROWDRV_1.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1.I69.MX_npd _WD1.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd1.I69._nr.MXNA1 _WD1.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXNA2 _WD1.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXPA1 _WD1.ROWSEL NXP0_0 _WD1.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd1.I69._nr.MXPA2 _WD1.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_0.MXN11 WL2 _WD1._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN8 _WD1._ROWDRV_0.NWL _WD1.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_0.MXP1 WL2 _WD1._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_0.MXP12 _WD1._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_0.MXP13 _WD1._ROWDRV_0.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_1.MXN11 WL3 _WD1._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_1.MXN8 _WD1._ROWDRV_1.NWL _WD1.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_1.MXP1 WL3 _WD1._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_1.MXP12 _WD1._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_1.MXP13 _WD1._ROWDRV_1.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10.I69.MX_npd _WD10.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10.I69._nr.MXNA1 _WD10.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXNA2 _WD10.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXPA1 _WD10.ROWSEL NXP0_2 _WD10.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd10.I69._nr.MXPA2 _WD10.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_0.MXN11 WL20 _WD10._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN8 _WD10._ROWDRV_0.NWL _WD10.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_0.MXP1 WL20 _WD10._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_0.MXP12 _WD10._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_0.MXP13 _WD10._ROWDRV_0.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_1.MXN11 WL21 _WD10._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_1.MXN8 _WD10._ROWDRV_1.NWL _WD10.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_1.MXP1 WL21 _WD10._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_1.MXP12 _WD10._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_1.MXP13 _WD10._ROWDRV_1.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11.I69.MX_npd _WD11.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11.I69._nr.MXNA1 _WD11.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXNA2 _WD11.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXPA1 _WD11.ROWSEL NXP0_2 _WD11.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd11.I69._nr.MXPA2 _WD11.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_0.MXN11 WL22 _WD11._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN8 _WD11._ROWDRV_0.NWL _WD11.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_0.MXP1 WL22 _WD11._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_0.MXP12 _WD11._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_0.MXP13 _WD11._ROWDRV_0.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_1.MXN11 WL23 _WD11._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_1.MXN8 _WD11._ROWDRV_1.NWL _WD11.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_1.MXP1 WL23 _WD11._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_1.MXP12 _WD11._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_1.MXP13 _WD11._ROWDRV_1.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12.I69.MX_npd _WD12.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12.I69._nr.MXNA1 _WD12.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXNA2 _WD12.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXPA1 _WD12.ROWSEL NXP0_3 _WD12.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd12.I69._nr.MXPA2 _WD12.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_0.MXN11 WL24 _WD12._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN8 _WD12._ROWDRV_0.NWL _WD12.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_0.MXP1 WL24 _WD12._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_0.MXP12 _WD12._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_0.MXP13 _WD12._ROWDRV_0.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_1.MXN11 WL25 _WD12._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_1.MXN8 _WD12._ROWDRV_1.NWL _WD12.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_1.MXP1 WL25 _WD12._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_1.MXP12 _WD12._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_1.MXP13 _WD12._ROWDRV_1.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13.I69.MX_npd _WD13.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13.I69._nr.MXNA1 _WD13.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXNA2 _WD13.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXPA1 _WD13.ROWSEL NXP0_3 _WD13.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd13.I69._nr.MXPA2 _WD13.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_0.MXN11 WL26 _WD13._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN8 _WD13._ROWDRV_0.NWL _WD13.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_0.MXP1 WL26 _WD13._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_0.MXP12 _WD13._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_0.MXP13 _WD13._ROWDRV_0.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_1.MXN11 WL27 _WD13._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_1.MXN8 _WD13._ROWDRV_1.NWL _WD13.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_1.MXP1 WL27 _WD13._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_1.MXP12 _WD13._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_1.MXP13 _WD13._ROWDRV_1.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14.I69.MX_npd _WD14.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14.I69._nr.MXNA1 _WD14.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXNA2 _WD14.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXPA1 _WD14.ROWSEL NXP0_3 _WD14.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd14.I69._nr.MXPA2 _WD14.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_0.MXN11 WL28 _WD14._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN8 _WD14._ROWDRV_0.NWL _WD14.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_0.MXP1 WL28 _WD14._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_0.MXP12 _WD14._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_0.MXP13 _WD14._ROWDRV_0.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_1.MXN11 WL29 _WD14._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_1.MXN8 _WD14._ROWDRV_1.NWL _WD14.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_1.MXP1 WL29 _WD14._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_1.MXP12 _WD14._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_1.MXP13 _WD14._ROWDRV_1.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd15.I69.MX_npd _WD15.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd15.I69._nr.MXNA1 _WD15.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69._nr.MXNA2 _WD15.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69._nr.MXPA1 _WD15.ROWSEL NXP0_3 _WD15.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd15.I69._nr.MXPA2 _WD15.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd15._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd15._rowdrv_0.MXN11 WL30 _WD15._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd15._rowdrv_0.MXN8 _WD15._ROWDRV_0.NWL _WD15.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd15._rowdrv_0.MXP1 WL30 _WD15._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd15._rowdrv_0.MXP12 _WD15._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd15._rowdrv_0.MXP13 _WD15._ROWDRV_0.NWL _WD15.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd15._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd15._rowdrv_1.MXN11 WL31 _WD15._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd15._rowdrv_1.MXN8 _WD15._ROWDRV_1.NWL _WD15.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd15._rowdrv_1.MXP1 WL31 _WD15._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd15._rowdrv_1.MXP12 _WD15._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd15._rowdrv_1.MXP13 _WD15._ROWDRV_1.NWL _WD15.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2.I69.MX_npd _WD2.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd2.I69._nr.MXNA1 _WD2.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXNA2 _WD2.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXPA1 _WD2.ROWSEL NXP0_0 _WD2.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd2.I69._nr.MXPA2 _WD2.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_0.MXN11 WL4 _WD2._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN8 _WD2._ROWDRV_0.NWL _WD2.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_0.MXP1 WL4 _WD2._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_0.MXP12 _WD2._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_0.MXP13 _WD2._ROWDRV_0.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_1.MXN11 WL5 _WD2._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_1.MXN8 _WD2._ROWDRV_1.NWL _WD2.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_1.MXP1 WL5 _WD2._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_1.MXP12 _WD2._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_1.MXP13 _WD2._ROWDRV_1.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3.I69.MX_npd _WD3.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd3.I69._nr.MXNA1 _WD3.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXNA2 _WD3.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXPA1 _WD3.ROWSEL NXP0_0 _WD3.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd3.I69._nr.MXPA2 _WD3.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_0.MXN11 WL6 _WD3._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN8 _WD3._ROWDRV_0.NWL _WD3.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_0.MXP1 WL6 _WD3._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_0.MXP12 _WD3._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_0.MXP13 _WD3._ROWDRV_0.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_1.MXN11 WL7 _WD3._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_1.MXN8 _WD3._ROWDRV_1.NWL _WD3.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_1.MXP1 WL7 _WD3._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_1.MXP12 _WD3._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_1.MXP13 _WD3._ROWDRV_1.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4.I69.MX_npd _WD4.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd4.I69._nr.MXNA1 _WD4.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXNA2 _WD4.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXPA1 _WD4.ROWSEL NXP0_1 _WD4.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd4.I69._nr.MXPA2 _WD4.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_0.MXN11 WL8 _WD4._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN8 _WD4._ROWDRV_0.NWL _WD4.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_0.MXP1 WL8 _WD4._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_0.MXP12 _WD4._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_0.MXP13 _WD4._ROWDRV_0.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_1.MXN11 WL9 _WD4._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_1.MXN8 _WD4._ROWDRV_1.NWL _WD4.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_1.MXP1 WL9 _WD4._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_1.MXP12 _WD4._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_1.MXP13 _WD4._ROWDRV_1.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5.I69.MX_npd _WD5.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd5.I69._nr.MXNA1 _WD5.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXNA2 _WD5.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXPA1 _WD5.ROWSEL NXP0_1 _WD5.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd5.I69._nr.MXPA2 _WD5.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_0.MXN11 WL10 _WD5._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN8 _WD5._ROWDRV_0.NWL _WD5.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_0.MXP1 WL10 _WD5._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_0.MXP12 _WD5._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_0.MXP13 _WD5._ROWDRV_0.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_1.MXN11 WL11 _WD5._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_1.MXN8 _WD5._ROWDRV_1.NWL _WD5.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_1.MXP1 WL11 _WD5._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_1.MXP12 _WD5._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_1.MXP13 _WD5._ROWDRV_1.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd54.I69.MX_npd _WD54.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd54.I69._nr.MXNA1 _WD54.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69._nr.MXNA2 _WD54.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69._nr.MXPA1 _WD54.ROWSEL NXP0_5 _WD54.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd54.I69._nr.MXPA2 _WD54.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd54._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd54._rowdrv_0.MXN11 WL44 _WD54._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd54._rowdrv_0.MXN8 _WD54._ROWDRV_0.NWL _WD54.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd54._rowdrv_0.MXP1 WL44 _WD54._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd54._rowdrv_0.MXP12 _WD54._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd54._rowdrv_0.MXP13 _WD54._ROWDRV_0.NWL _WD54.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd54._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd54._rowdrv_1.MXN11 WL45 _WD54._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd54._rowdrv_1.MXN8 _WD54._ROWDRV_1.NWL _WD54.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd54._rowdrv_1.MXP1 WL45 _WD54._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd54._rowdrv_1.MXP12 _WD54._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd54._rowdrv_1.MXP13 _WD54._ROWDRV_1.NWL _WD54.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd55.I69.MX_npd _WD55.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd55.I69._nr.MXNA1 _WD55.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69._nr.MXNA2 _WD55.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69._nr.MXPA1 _WD55.ROWSEL NXP0_5 _WD55.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd55.I69._nr.MXPA2 _WD55.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd55._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd55._rowdrv_0.MXN11 WL46 _WD55._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd55._rowdrv_0.MXN8 _WD55._ROWDRV_0.NWL _WD55.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd55._rowdrv_0.MXP1 WL46 _WD55._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd55._rowdrv_0.MXP12 _WD55._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd55._rowdrv_0.MXP13 _WD55._ROWDRV_0.NWL _WD55.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd55._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd55._rowdrv_1.MXN11 WL47 _WD55._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd55._rowdrv_1.MXN8 _WD55._ROWDRV_1.NWL _WD55.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd55._rowdrv_1.MXP1 WL47 _WD55._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd55._rowdrv_1.MXP12 _WD55._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd55._rowdrv_1.MXP13 _WD55._ROWDRV_1.NWL _WD55.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd56.I69.MX_npd _WD56.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd56.I69._nr.MXNA1 _WD56.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69._nr.MXNA2 _WD56.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69._nr.MXPA1 _WD56.ROWSEL NXP0_6 _WD56.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd56.I69._nr.MXPA2 _WD56.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd56._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd56._rowdrv_0.MXN11 WL48 _WD56._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd56._rowdrv_0.MXN8 _WD56._ROWDRV_0.NWL _WD56.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd56._rowdrv_0.MXP1 WL48 _WD56._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd56._rowdrv_0.MXP12 _WD56._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd56._rowdrv_0.MXP13 _WD56._ROWDRV_0.NWL _WD56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd56._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd56._rowdrv_1.MXN11 WL49 _WD56._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd56._rowdrv_1.MXN8 _WD56._ROWDRV_1.NWL _WD56.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd56._rowdrv_1.MXP1 WL49 _WD56._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd56._rowdrv_1.MXP12 _WD56._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd56._rowdrv_1.MXP13 _WD56._ROWDRV_1.NWL _WD56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd57.I69.MX_npd _WD57.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd57.I69._nr.MXNA1 _WD57.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69._nr.MXNA2 _WD57.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69._nr.MXPA1 _WD57.ROWSEL NXP0_6 _WD57.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd57.I69._nr.MXPA2 _WD57.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd57._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd57._rowdrv_0.MXN11 WL50 _WD57._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd57._rowdrv_0.MXN8 _WD57._ROWDRV_0.NWL _WD57.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd57._rowdrv_0.MXP1 WL50 _WD57._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd57._rowdrv_0.MXP12 _WD57._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd57._rowdrv_0.MXP13 _WD57._ROWDRV_0.NWL _WD57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd57._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd57._rowdrv_1.MXN11 WL51 _WD57._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd57._rowdrv_1.MXN8 _WD57._ROWDRV_1.NWL _WD57.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd57._rowdrv_1.MXP1 WL51 _WD57._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd57._rowdrv_1.MXP12 _WD57._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd57._rowdrv_1.MXP13 _WD57._ROWDRV_1.NWL _WD57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd58.I69.MX_npd _WD58.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd58.I69._nr.MXNA1 _WD58.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69._nr.MXNA2 _WD58.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69._nr.MXPA1 _WD58.ROWSEL NXP0_6 _WD58.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd58.I69._nr.MXPA2 _WD58.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd58._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd58._rowdrv_0.MXN11 WL52 _WD58._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd58._rowdrv_0.MXN8 _WD58._ROWDRV_0.NWL _WD58.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd58._rowdrv_0.MXP1 WL52 _WD58._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd58._rowdrv_0.MXP12 _WD58._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd58._rowdrv_0.MXP13 _WD58._ROWDRV_0.NWL _WD58.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd58._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd58._rowdrv_1.MXN11 WL53 _WD58._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd58._rowdrv_1.MXN8 _WD58._ROWDRV_1.NWL _WD58.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd58._rowdrv_1.MXP1 WL53 _WD58._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd58._rowdrv_1.MXP12 _WD58._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd58._rowdrv_1.MXP13 _WD58._ROWDRV_1.NWL _WD58.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd59.I69.MX_npd _WD59.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd59.I69._nr.MXNA1 _WD59.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69._nr.MXNA2 _WD59.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69._nr.MXPA1 _WD59.ROWSEL NXP0_6 _WD59.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd59.I69._nr.MXPA2 _WD59.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd59._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd59._rowdrv_0.MXN11 WL54 _WD59._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd59._rowdrv_0.MXN8 _WD59._ROWDRV_0.NWL _WD59.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd59._rowdrv_0.MXP1 WL54 _WD59._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd59._rowdrv_0.MXP12 _WD59._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd59._rowdrv_0.MXP13 _WD59._ROWDRV_0.NWL _WD59.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd59._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd59._rowdrv_1.MXN11 WL55 _WD59._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd59._rowdrv_1.MXN8 _WD59._ROWDRV_1.NWL _WD59.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd59._rowdrv_1.MXP1 WL55 _WD59._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd59._rowdrv_1.MXP12 _WD59._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd59._rowdrv_1.MXP13 _WD59._ROWDRV_1.NWL _WD59.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6.I69.MX_npd _WD6.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd6.I69._nr.MXNA1 _WD6.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXNA2 _WD6.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXPA1 _WD6.ROWSEL NXP0_1 _WD6.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd6.I69._nr.MXPA2 _WD6.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_0.MXN11 WL12 _WD6._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN8 _WD6._ROWDRV_0.NWL _WD6.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_0.MXP1 WL12 _WD6._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_0.MXP12 _WD6._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_0.MXP13 _WD6._ROWDRV_0.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_1.MXN11 WL13 _WD6._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_1.MXN8 _WD6._ROWDRV_1.NWL _WD6.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_1.MXP1 WL13 _WD6._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_1.MXP12 _WD6._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_1.MXP13 _WD6._ROWDRV_1.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd60.I69.MX_npd _WD60.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd60.I69._nr.MXNA1 _WD60.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69._nr.MXNA2 _WD60.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69._nr.MXPA1 _WD60.ROWSEL NXP0_7 _WD60.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd60.I69._nr.MXPA2 _WD60.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd60._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd60._rowdrv_0.MXN11 WL56 _WD60._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd60._rowdrv_0.MXN8 _WD60._ROWDRV_0.NWL _WD60.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd60._rowdrv_0.MXP1 WL56 _WD60._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd60._rowdrv_0.MXP12 _WD60._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd60._rowdrv_0.MXP13 _WD60._ROWDRV_0.NWL _WD60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd60._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd60._rowdrv_1.MXN11 WL57 _WD60._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd60._rowdrv_1.MXN8 _WD60._ROWDRV_1.NWL _WD60.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd60._rowdrv_1.MXP1 WL57 _WD60._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd60._rowdrv_1.MXP12 _WD60._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd60._rowdrv_1.MXP13 _WD60._ROWDRV_1.NWL _WD60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd61.I69.MX_npd _WD61.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd61.I69._nr.MXNA1 _WD61.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69._nr.MXNA2 _WD61.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69._nr.MXPA1 _WD61.ROWSEL NXP0_7 _WD61.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd61.I69._nr.MXPA2 _WD61.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd61._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd61._rowdrv_0.MXN11 WL58 _WD61._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd61._rowdrv_0.MXN8 _WD61._ROWDRV_0.NWL _WD61.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd61._rowdrv_0.MXP1 WL58 _WD61._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd61._rowdrv_0.MXP12 _WD61._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd61._rowdrv_0.MXP13 _WD61._ROWDRV_0.NWL _WD61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd61._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd61._rowdrv_1.MXN11 WL59 _WD61._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd61._rowdrv_1.MXN8 _WD61._ROWDRV_1.NWL _WD61.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd61._rowdrv_1.MXP1 WL59 _WD61._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd61._rowdrv_1.MXP12 _WD61._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd61._rowdrv_1.MXP13 _WD61._ROWDRV_1.NWL _WD61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd62.I69.MX_npd _WD62.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd62.I69._nr.MXNA1 _WD62.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69._nr.MXNA2 _WD62.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69._nr.MXPA1 _WD62.ROWSEL NXP0_7 _WD62.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd62.I69._nr.MXPA2 _WD62.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd62._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd62._rowdrv_0.MXN11 WL60 _WD62._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd62._rowdrv_0.MXN8 _WD62._ROWDRV_0.NWL _WD62.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd62._rowdrv_0.MXP1 WL60 _WD62._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd62._rowdrv_0.MXP12 _WD62._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd62._rowdrv_0.MXP13 _WD62._ROWDRV_0.NWL _WD62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd62._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd62._rowdrv_1.MXN11 WL61 _WD62._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd62._rowdrv_1.MXN8 _WD62._ROWDRV_1.NWL _WD62.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd62._rowdrv_1.MXP1 WL61 _WD62._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd62._rowdrv_1.MXP12 _WD62._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd62._rowdrv_1.MXP13 _WD62._ROWDRV_1.NWL _WD62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7.I69.MX_npd _WD7.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd7.I69._nr.MXNA1 _WD7.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXNA2 _WD7.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXPA1 _WD7.ROWSEL NXP0_1 _WD7.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd7.I69._nr.MXPA2 _WD7.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_0.MXN11 WL14 _WD7._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN8 _WD7._ROWDRV_0.NWL _WD7.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_0.MXP1 WL14 _WD7._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_0.MXP12 _WD7._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_0.MXP13 _WD7._ROWDRV_0.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_1.MXN11 WL15 _WD7._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_1.MXN8 _WD7._ROWDRV_1.NWL _WD7.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_1.MXP1 WL15 _WD7._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_1.MXP12 _WD7._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_1.MXP13 _WD7._ROWDRV_1.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8.I69.MX_npd _WD8.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd8.I69._nr.MXNA1 _WD8.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXNA2 _WD8.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXPA1 _WD8.ROWSEL NXP0_2 _WD8.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd8.I69._nr.MXPA2 _WD8.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_0.MXN11 WL16 _WD8._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN8 _WD8._ROWDRV_0.NWL _WD8.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_0.MXP1 WL16 _WD8._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_0.MXP12 _WD8._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_0.MXP13 _WD8._ROWDRV_0.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_1.MXN11 WL17 _WD8._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_1.MXN8 _WD8._ROWDRV_1.NWL _WD8.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_1.MXP1 WL17 _WD8._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_1.MXP12 _WD8._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_1.MXP13 _WD8._ROWDRV_1.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9.I69.MX_npd _WD9.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd9.I69._nr.MXNA1 _WD9.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXNA2 _WD9.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXPA1 _WD9.ROWSEL NXP0_2 _WD9.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd9.I69._nr.MXPA2 _WD9.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_0.MXN11 WL18 _WD9._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN8 _WD9._ROWDRV_0.NWL _WD9.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_0.MXP1 WL18 _WD9._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_0.MXP12 _WD9._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_0.MXP13 _WD9._ROWDRV_0.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_1.MXN11 WL19 _WD9._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_1.MXN8 _WD9._ROWDRV_1.NWL _WD9.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_1.MXP1 WL19 _WD9._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_1.MXP12 _WD9._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_1.MXP13 _WD9._ROWDRV_1.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wdxtop.I69.MX_npd _WDXTOP.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA1 _WDXTOP.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA2 _WDXTOP.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXPA1 _WDXTOP.ROWSEL NXP0_7 _WDXTOP.I69._NR.P1 VNWP
+  P11LL_CKT W=0.855U L=0.04U
X_M_wdxtop.I69._nr.MXPA2 _WDXTOP.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wdxtop._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_0.MXN11 WL62 _WDXTOP._ROWDRV_0.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_0.MXN8 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL NI6 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_0.MXP1 WL62 _WDXTOP._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_0.MXP12 _WDXTOP._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_0.MXP13 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_wdxtop._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_1.MXN11 WL63 _WDXTOP._ROWDRV_1.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_1.MXN8 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL NI7 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_1.MXP1 WL63 _WDXTOP._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_1.MXP12 _WDXTOP._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_1.MXP13 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_xdec0._dec.I1_0.MXNA1 _XDEC0._DEC.NDEC[0] NA[0] _XDEC0._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA2 _XDEC0._DEC.I1_0.N2 NA[1] _XDEC0._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA3 _XDEC0._DEC.I1_0.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_0.MXPA1 _XDEC0._DEC.NDEC[0] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA2 _XDEC0._DEC.NDEC[0] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA3 _XDEC0._DEC.NDEC[0] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXNA1 _XDEC0._DEC.NDEC[1] IA[0] _XDEC0._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA2 _XDEC0._DEC.I1_1.N2 NA[1] _XDEC0._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA3 _XDEC0._DEC.I1_1.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_1.MXPA1 _XDEC0._DEC.NDEC[1] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA2 _XDEC0._DEC.NDEC[1] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA3 _XDEC0._DEC.NDEC[1] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXNA1 _XDEC0._DEC.NDEC[2] NA[0] _XDEC0._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA2 _XDEC0._DEC.I1_2.N2 IA[1] _XDEC0._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA3 _XDEC0._DEC.I1_2.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_2.MXPA1 _XDEC0._DEC.NDEC[2] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA2 _XDEC0._DEC.NDEC[2] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA3 _XDEC0._DEC.NDEC[2] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXNA1 _XDEC0._DEC.NDEC[3] IA[0] _XDEC0._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA2 _XDEC0._DEC.I1_3.N2 IA[1] _XDEC0._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA3 _XDEC0._DEC.I1_3.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_3.MXPA1 _XDEC0._DEC.NDEC[3] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA2 _XDEC0._DEC.NDEC[3] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA3 _XDEC0._DEC.NDEC[3] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXNA1 _XDEC0._DEC.NDEC[4] NA[0] _XDEC0._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA2 _XDEC0._DEC.I1_4.N2 NA[1] _XDEC0._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA3 _XDEC0._DEC.I1_4.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_4.MXPA1 _XDEC0._DEC.NDEC[4] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA2 _XDEC0._DEC.NDEC[4] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA3 _XDEC0._DEC.NDEC[4] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXNA1 _XDEC0._DEC.NDEC[5] IA[0] _XDEC0._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA2 _XDEC0._DEC.I1_5.N2 NA[1] _XDEC0._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA3 _XDEC0._DEC.I1_5.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_5.MXPA1 _XDEC0._DEC.NDEC[5] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA2 _XDEC0._DEC.NDEC[5] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA3 _XDEC0._DEC.NDEC[5] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXNA1 _XDEC0._DEC.NDEC[6] NA[0] _XDEC0._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA2 _XDEC0._DEC.I1_6.N2 IA[1] _XDEC0._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA3 _XDEC0._DEC.I1_6.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_6.MXPA1 _XDEC0._DEC.NDEC[6] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA2 _XDEC0._DEC.NDEC[6] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA3 _XDEC0._DEC.NDEC[6] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXNA1 _XDEC0._DEC.NDEC[7] IA[0] _XDEC0._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA2 _XDEC0._DEC.I1_7.N2 IA[1] _XDEC0._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA3 _XDEC0._DEC.I1_7.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_7.MXPA1 _XDEC0._DEC.NDEC[7] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA2 _XDEC0._DEC.NDEC[7] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA3 _XDEC0._DEC.NDEC[7] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I3_0.MXNA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_0.MXPA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_1.MXNA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_1.MXPA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_2.MXNA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_2.MXPA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_3.MXNA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_3.MXPA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_4.MXNA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_4.MXPA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_5.MXNA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_5.MXPA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_6.MXNA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_6.MXPA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_7.MXNA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_7.MXPA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._iv_nxp_0.MXNA1 NXP0_0 _XDEC0.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_0.MXPA1 NXP0_0 _XDEC0.XP[0] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXNA1 NXP0_1 _XDEC0.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXPA1 NXP0_1 _XDEC0.XP[1] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXNA1 NXP0_2 _XDEC0.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXPA1 NXP0_2 _XDEC0.XP[2] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXNA1 NXP0_3 _XDEC0.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXPA1 NXP0_3 _XDEC0.XP[3] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXNA1 NXP0_4 _XDEC0.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXPA1 NXP0_4 _XDEC0.XP[4] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXNA1 NXP0_5 _XDEC0.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXPA1 NXP0_5 _XDEC0.XP[5] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXNA1 NXP0_6 _XDEC0.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXPA1 NXP0_6 _XDEC0.XP[6] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXNA1 NXP0_7 _XDEC0.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXPA1 NXP0_7 _XDEC0.XP[7] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXNA1 _XDEC1._DEC.NDEC[0] NA[3] _XDEC1._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA2 _XDEC1._DEC.I1_0.N2 NA[4] _XDEC1._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA3 _XDEC1._DEC.I1_0.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXPA1 _XDEC1._DEC.NDEC[0] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA2 _XDEC1._DEC.NDEC[0] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA3 _XDEC1._DEC.NDEC[0] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXNA1 _XDEC1._DEC.NDEC[1] IA[3] _XDEC1._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA2 _XDEC1._DEC.I1_1.N2 NA[4] _XDEC1._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA3 _XDEC1._DEC.I1_1.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_1.MXPA1 _XDEC1._DEC.NDEC[1] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA2 _XDEC1._DEC.NDEC[1] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA3 _XDEC1._DEC.NDEC[1] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXNA1 _XDEC1._DEC.NDEC[2] NA[3] _XDEC1._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA2 _XDEC1._DEC.I1_2.N2 IA[4] _XDEC1._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA3 _XDEC1._DEC.I1_2.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_2.MXPA1 _XDEC1._DEC.NDEC[2] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA2 _XDEC1._DEC.NDEC[2] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA3 _XDEC1._DEC.NDEC[2] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXNA1 _XDEC1._DEC.NDEC[3] IA[3] _XDEC1._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA2 _XDEC1._DEC.I1_3.N2 IA[4] _XDEC1._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA3 _XDEC1._DEC.I1_3.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_3.MXPA1 _XDEC1._DEC.NDEC[3] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA2 _XDEC1._DEC.NDEC[3] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA3 _XDEC1._DEC.NDEC[3] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXNA1 _XDEC1._DEC.NDEC[4] NA[3] _XDEC1._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA2 _XDEC1._DEC.I1_4.N2 NA[4] _XDEC1._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA3 _XDEC1._DEC.I1_4.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_4.MXPA1 _XDEC1._DEC.NDEC[4] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA2 _XDEC1._DEC.NDEC[4] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA3 _XDEC1._DEC.NDEC[4] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXNA1 _XDEC1._DEC.NDEC[5] IA[3] _XDEC1._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA2 _XDEC1._DEC.I1_5.N2 NA[4] _XDEC1._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA3 _XDEC1._DEC.I1_5.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_5.MXPA1 _XDEC1._DEC.NDEC[5] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA2 _XDEC1._DEC.NDEC[5] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA3 _XDEC1._DEC.NDEC[5] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXNA1 _XDEC1._DEC.NDEC[6] NA[3] _XDEC1._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA2 _XDEC1._DEC.I1_6.N2 IA[4] _XDEC1._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA3 _XDEC1._DEC.I1_6.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_6.MXPA1 _XDEC1._DEC.NDEC[6] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA2 _XDEC1._DEC.NDEC[6] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA3 _XDEC1._DEC.NDEC[6] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXNA1 _XDEC1._DEC.NDEC[7] IA[3] _XDEC1._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA2 _XDEC1._DEC.I1_7.N2 IA[4] _XDEC1._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA3 _XDEC1._DEC.I1_7.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_7.MXPA1 _XDEC1._DEC.NDEC[7] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA2 _XDEC1._DEC.NDEC[7] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA3 _XDEC1._DEC.NDEC[7] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I3_0.MXNA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_0.MXPA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_1.MXNA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_1.MXPA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_2.MXNA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_2.MXPA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_3.MXNA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_3.MXPA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_4.MXNA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_4.MXPA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_5.MXNA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_5.MXPA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_6.MXNA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_6.MXPA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_7.MXNA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_7.MXPA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._iv_nxp_0.MXNA1 NXP1_0 _XDEC1.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_0.MXPA1 NXP1_0 _XDEC1.XP[0] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXNA1 NXP1_1 _XDEC1.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXPA1 NXP1_1 _XDEC1.XP[1] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXNA1 NXP1_2 _XDEC1.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXPA1 NXP1_2 _XDEC1.XP[2] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXNA1 NXP1_3 _XDEC1.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXPA1 NXP1_3 _XDEC1.XP[3] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXNA1 NXP1_4 _XDEC1.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXPA1 NXP1_4 _XDEC1.XP[4] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXNA1 NXP1_5 _XDEC1.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXPA1 NXP1_5 _XDEC1.XP[5] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXNA1 NXP1_6 _XDEC1.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXPA1 NXP1_6 _XDEC1.XP[6] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXNA1 NXP1_7 _XDEC1.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXPA1 NXP1_7 _XDEC1.XP[7] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
.ENDS RAMSP4096X16WDX64
****
.SUBCKT RAMSP4096X16WDDRVCOL A[0] A[1] A[2] A[3] A[4] A[5] BPGEN BRET1N BRET2N
+  DBL DWL EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACT_CC NGWE RET_0 RET_1 SAE_DUMMY VDDC_LEFT VDDC_RIGHT VDDP
+  VDDPE VNWC VNWP VSSE WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8
+  WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19
+  WL0_20 WL0_21 WL0_22 WL0_23 WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29
+  WL0_30 WL0_31 WL0_32 WL0_33 WL0_34 WL0_35 WL0_36 WL0_37 WL0_38 WL0_39
+  WL0_40 WL0_41 WL0_42 WL0_43 WL0_44 WL0_45 WL0_46 WL0_47 WL0_48 WL0_49
+  WL0_50 WL0_51 WL0_52 WL0_53 WL0_54 WL0_55 WL0_56 WL0_57 WL0_58 WL0_59
+  WL0_60 WL0_61 WL0_62 WL0_63 WL0_64 WL0_65 WL0_66 WL0_67 WL0_68 WL0_69
+  WL0_70 WL0_71 WL0_72 WL0_73 WL0_74 WL0_75 WL0_76 WL0_77 WL0_78 WL0_79
+  WL0_80 WL0_81 WL0_82 WL0_83 WL0_84 WL0_85 WL0_86 WL0_87 WL0_88 WL0_89
+  WL0_90 WL0_91 WL0_92 WL0_93 WL0_94 WL0_95 WL0_96 WL0_97 WL0_98 WL0_99
+  WL0_100 WL0_101 WL0_102 WL0_103 WL0_104 WL0_105 WL0_106 WL0_107 WL0_108
+  WL0_109 WL0_110 WL0_111 WL0_112 WL0_113 WL0_114 WL0_115 WL0_116 WL0_117
+  WL0_118 WL0_119 WL0_120 WL0_121 WL0_122 WL0_123 WL0_124 WL0_125 WL0_126
+  WL0_127 WL0_128 WL0_129 WL0_130 WL0_131 WL0_132 WL0_133 WL0_134 WL0_135
+  WL0_136 WL0_137 WL0_138 WL0_139 WL0_140 WL0_141 WL0_142 WL0_143 WL0_144
+  WL0_145 WL0_146 WL0_147 WL0_148 WL0_149 WL0_150 WL0_151 WL0_152 WL0_153
+  WL0_154 WL0_155 WL0_156 WL0_157 WL0_158 WL0_159 WL0_160 WL0_161 WL0_162
+  WL0_163 WL0_164 WL0_165 WL0_166 WL0_167 WL0_168 WL0_169 WL0_170 WL0_171
+  WL0_172 WL0_173 WL0_174 WL0_175 WL0_176 WL0_177 WL0_178 WL0_179 WL0_180
+  WL0_181 WL0_182 WL0_183 WL0_184 WL0_185 WL0_186 WL0_187 WL0_188 WL0_189
+  WL0_190 WL0_191 WL0_192 WL0_193 WL0_194 WL0_195 WL0_196 WL0_197 WL0_198
+  WL0_199 WL0_200 WL0_201 WL0_202 WL0_203 WL0_204 WL0_205 WL0_206 WL0_207
+  WL0_208 WL0_209 WL0_210 WL0_211 WL0_212 WL0_213 WL0_214 WL0_215 WL0_216
+  WL0_217 WL0_218 WL0_219 WL0_220 WL0_221 WL0_222 WL0_223 WL0_224 WL1_0 WL1_1
+  WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13
+  WL1_14 WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23
+  WL1_24 WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33
+  WL1_34 WL1_35 WL1_36 WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43
+  WL1_44 WL1_45 WL1_46 WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53
+  WL1_54 WL1_55 WL1_56 WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63
+  WL1_64 WL1_65 WL1_66 WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73
+  WL1_74 WL1_75 WL1_76 WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83
+  WL1_84 WL1_85 WL1_86 WL1_87 WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93
+  WL1_94 WL1_95 WL1_96 WL1_97 WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103
+  WL1_104 WL1_105 WL1_106 WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112
+  WL1_113 WL1_114 WL1_115 WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121
+  WL1_122 WL1_123 WL1_124 WL1_125 WL1_126 WL1_127 WL1_128 WL1_129 WL1_130
+  WL1_131 WL1_132 WL1_133 WL1_134 WL1_135 WL1_136 WL1_137 WL1_138 WL1_139
+  WL1_140 WL1_141 WL1_142 WL1_143 WL1_144 WL1_145 WL1_146 WL1_147 WL1_148
+  WL1_149 WL1_150 WL1_151 WL1_152 WL1_153 WL1_154 WL1_155 WL1_156 WL1_157
+  WL1_158 WL1_159 WL1_160 WL1_161 WL1_162 WL1_163 WL1_164 WL1_165 WL1_166
+  WL1_167 WL1_168 WL1_169 WL1_170 WL1_171 WL1_172 WL1_173 WL1_174 WL1_175
+  WL1_176 WL1_177 WL1_178 WL1_179 WL1_180 WL1_181 WL1_182 WL1_183 WL1_184
+  WL1_185 WL1_186 WL1_187 WL1_188 WL1_189 WL1_190 WL1_191 WL1_192 WL1_193
+  WL1_194 WL1_195 WL1_196 WL1_197 WL1_198 WL1_199 WL1_200 WL1_201 WL1_202
+  WL1_203 WL1_204 WL1_205 WL1_206 WL1_207 WL1_208 WL1_209 WL1_210 WL1_211
+  WL1_212 WL1_213 WL1_214 WL1_215 WL1_216 WL1_217 WL1_218 WL1_219 WL1_220
+  WL1_221 WL1_222 WL1_223 WL1_224 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11
+  WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26
+  WL27 WL28 WL29 WL30 WL31 WL32 WL33 WL34 WL35 WL36 WL37 WL38 WL39 WL40 WL41
+  WL42 WL43 WL44 WL45 WL46 WL47 WL48 WL49 WL50 WL51 WL52 WL53 WL54 WL55 WL56
+  WL57 WL58 WL59 WL60 WL61 WL62 WL63
** RAMSP4096X16WDDRVCOL: 5563 flat devices **
XWD_BOT BPGEN A[0] A[1] A[2] A[3] A[4] A[5] DBL RET_0 DWL EMA0 EMA1 EMA2
+  GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 BRET2N
+  NACT_CC NGWE NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2
+  NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4
+  NXP1_5 NXP1_6 NXP1_7 RET_1 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5
+  ROWCLK6 ROWCLK7 SAE_DUMMY VNWC VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE
+  VSSE WL0_0 WL1_0 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11 WL12 WL13 WL14
+  WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26 WL27 WL28 WL29
+  WL30 WL31 WL32 WL33 WL34 WL35 WL36 WL37 WL38 WL39 WL40 WL41 WL42 WL43 WL44
+  WL45 WL46 WL47 WL48 WL49 WL50 WL51 WL52 WL53 WL54 WL55 WL56 WL57 WL58 WL59
+  WL60 WL61 WL62 WL63 RAMSP4096X16WDX64
XWD_I0 BPGEN DBL NXP0_0 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_1 WL1_1 RAMSP4096X16WDX2
XWD_I1 BPGEN DBL NXP0_0 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_2 WL1_2 RAMSP4096X16WDX2
XWD_I10 BPGEN DBL NXP0_2 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_11 WL1_11
+  RAMSP4096X16WDX2
XWD_I100 BPGEN DBL NXP0_1 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_101 WL1_101
+  RAMSP4096X16WDX2
XWD_I101 BPGEN DBL NXP0_1 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_102 WL1_102
+  RAMSP4096X16WDX2
XWD_I102 BPGEN DBL NXP0_1 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_103 WL1_103
+  RAMSP4096X16WDX2
XWD_I103 BPGEN DBL NXP0_1 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_104 WL1_104
+  RAMSP4096X16WDX2
XWD_I104 BPGEN DBL NXP0_2 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_105 WL1_105
+  RAMSP4096X16WDX2
XWD_I105 BPGEN DBL NXP0_2 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_106 WL1_106
+  RAMSP4096X16WDX2
XWD_I106 BPGEN DBL NXP0_2 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_107 WL1_107
+  RAMSP4096X16WDX2
XWD_I107 BPGEN DBL NXP0_2 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_108 WL1_108
+  RAMSP4096X16WDX2
XWD_I108 BPGEN DBL NXP0_3 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_109 WL1_109
+  RAMSP4096X16WDX2
XWD_I109 BPGEN DBL NXP0_3 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_110 WL1_110
+  RAMSP4096X16WDX2
XWD_I11 BPGEN DBL NXP0_2 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_12 WL1_12
+  RAMSP4096X16WDX2
XWD_I110 BPGEN DBL NXP0_3 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_111 WL1_111
+  RAMSP4096X16WDX2
XWD_I111 BPGEN DBL NXP0_3 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_112 WL1_112
+  RAMSP4096X16WDX2
XWD_I112 BPGEN DBL NXP0_4 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_113 WL1_113
+  RAMSP4096X16WDX2
XWD_I113 BPGEN DBL NXP0_4 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_114 WL1_114
+  RAMSP4096X16WDX2
XWD_I114 BPGEN DBL NXP0_4 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_115 WL1_115
+  RAMSP4096X16WDX2
XWD_I115 BPGEN DBL NXP0_4 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_116 WL1_116
+  RAMSP4096X16WDX2
XWD_I116 BPGEN DBL NXP0_5 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_117 WL1_117
+  RAMSP4096X16WDX2
XWD_I117 BPGEN DBL NXP0_5 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_118 WL1_118
+  RAMSP4096X16WDX2
XWD_I118 BPGEN DBL NXP0_5 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_119 WL1_119
+  RAMSP4096X16WDX2
XWD_I119 BPGEN DBL NXP0_5 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_120 WL1_120
+  RAMSP4096X16WDX2
XWD_I12 BPGEN DBL NXP0_3 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_13 WL1_13
+  RAMSP4096X16WDX2
XWD_I120 BPGEN DBL NXP0_6 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_121 WL1_121
+  RAMSP4096X16WDX2
XWD_I121 BPGEN DBL NXP0_6 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_122 WL1_122
+  RAMSP4096X16WDX2
XWD_I122 BPGEN DBL NXP0_6 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_123 WL1_123
+  RAMSP4096X16WDX2
XWD_I123 BPGEN DBL NXP0_6 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_124 WL1_124
+  RAMSP4096X16WDX2
XWD_I124 BPGEN DBL NXP0_7 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_125 WL1_125
+  RAMSP4096X16WDX2
XWD_I125 BPGEN DBL NXP0_7 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_126 WL1_126
+  RAMSP4096X16WDX2
XWD_I126 BPGEN DBL NXP0_7 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_127 WL1_127
+  RAMSP4096X16WDX2
XWD_I127 BPGEN DBL NXP0_7 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_128 WL1_128
+  RAMSP4096X16WDX2
XWD_I128 BPGEN DBL NXP0_0 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_129 WL1_129
+  RAMSP4096X16WDX2
XWD_I129 BPGEN DBL NXP0_0 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_130 WL1_130
+  RAMSP4096X16WDX2
XWD_I13 BPGEN DBL NXP0_3 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_14 WL1_14
+  RAMSP4096X16WDX2
XWD_I130 BPGEN DBL NXP0_0 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_131 WL1_131
+  RAMSP4096X16WDX2
XWD_I131 BPGEN DBL NXP0_0 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_132 WL1_132
+  RAMSP4096X16WDX2
XWD_I132 BPGEN DBL NXP0_1 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_133 WL1_133
+  RAMSP4096X16WDX2
XWD_I133 BPGEN DBL NXP0_1 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_134 WL1_134
+  RAMSP4096X16WDX2
XWD_I134 BPGEN DBL NXP0_1 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_135 WL1_135
+  RAMSP4096X16WDX2
XWD_I135 BPGEN DBL NXP0_1 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_136 WL1_136
+  RAMSP4096X16WDX2
XWD_I136 BPGEN DBL NXP0_2 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_137 WL1_137
+  RAMSP4096X16WDX2
XWD_I137 BPGEN DBL NXP0_2 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_138 WL1_138
+  RAMSP4096X16WDX2
XWD_I138 BPGEN DBL NXP0_2 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_139 WL1_139
+  RAMSP4096X16WDX2
XWD_I139 BPGEN DBL NXP0_2 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_140 WL1_140
+  RAMSP4096X16WDX2
XWD_I14 BPGEN DBL NXP0_3 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_15 WL1_15
+  RAMSP4096X16WDX2
XWD_I140 BPGEN DBL NXP0_3 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_141 WL1_141
+  RAMSP4096X16WDX2
XWD_I141 BPGEN DBL NXP0_3 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_142 WL1_142
+  RAMSP4096X16WDX2
XWD_I142 BPGEN DBL NXP0_3 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_143 WL1_143
+  RAMSP4096X16WDX2
XWD_I143 BPGEN DBL NXP0_3 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_144 WL1_144
+  RAMSP4096X16WDX2
XWD_I144 BPGEN DBL NXP0_4 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_145 WL1_145
+  RAMSP4096X16WDX2
XWD_I145 BPGEN DBL NXP0_4 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_146 WL1_146
+  RAMSP4096X16WDX2
XWD_I146 BPGEN DBL NXP0_4 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_147 WL1_147
+  RAMSP4096X16WDX2
XWD_I147 BPGEN DBL NXP0_4 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_148 WL1_148
+  RAMSP4096X16WDX2
XWD_I148 BPGEN DBL NXP0_5 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_149 WL1_149
+  RAMSP4096X16WDX2
XWD_I149 BPGEN DBL NXP0_5 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_150 WL1_150
+  RAMSP4096X16WDX2
XWD_I15 BPGEN DBL NXP0_3 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_16 WL1_16
+  RAMSP4096X16WDX2
XWD_I150 BPGEN DBL NXP0_5 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_151 WL1_151
+  RAMSP4096X16WDX2
XWD_I151 BPGEN DBL NXP0_5 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_152 WL1_152
+  RAMSP4096X16WDX2
XWD_I152 BPGEN DBL NXP0_6 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_153 WL1_153
+  RAMSP4096X16WDX2
XWD_I153 BPGEN DBL NXP0_6 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_154 WL1_154
+  RAMSP4096X16WDX2
XWD_I154 BPGEN DBL NXP0_6 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_155 WL1_155
+  RAMSP4096X16WDX2
XWD_I155 BPGEN DBL NXP0_6 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_156 WL1_156
+  RAMSP4096X16WDX2
XWD_I156 BPGEN DBL NXP0_7 NXP1_5 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_157 WL1_157
+  RAMSP4096X16WDX2
XWD_I157 BPGEN DBL NXP0_7 NXP1_5 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_158 WL1_158
+  RAMSP4096X16WDX2
XWD_I158 BPGEN DBL NXP0_7 NXP1_5 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_159 WL1_159
+  RAMSP4096X16WDX2
XWD_I159 BPGEN DBL NXP0_7 NXP1_5 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_160 WL1_160
+  RAMSP4096X16WDX2
XWD_I16 BPGEN DBL NXP0_4 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_17 WL1_17
+  RAMSP4096X16WDX2
XWD_I160 BPGEN DBL NXP0_0 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_161 WL1_161
+  RAMSP4096X16WDX2
XWD_I161 BPGEN DBL NXP0_0 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_162 WL1_162
+  RAMSP4096X16WDX2
XWD_I162 BPGEN DBL NXP0_0 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_163 WL1_163
+  RAMSP4096X16WDX2
XWD_I163 BPGEN DBL NXP0_0 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_164 WL1_164
+  RAMSP4096X16WDX2
XWD_I164 BPGEN DBL NXP0_1 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_165 WL1_165
+  RAMSP4096X16WDX2
XWD_I165 BPGEN DBL NXP0_1 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_166 WL1_166
+  RAMSP4096X16WDX2
XWD_I166 BPGEN DBL NXP0_1 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_167 WL1_167
+  RAMSP4096X16WDX2
XWD_I167 BPGEN DBL NXP0_1 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_168 WL1_168
+  RAMSP4096X16WDX2
XWD_I168 BPGEN DBL NXP0_2 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_169 WL1_169
+  RAMSP4096X16WDX2
XWD_I169 BPGEN DBL NXP0_2 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_170 WL1_170
+  RAMSP4096X16WDX2
XWD_I17 BPGEN DBL NXP0_4 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_18 WL1_18
+  RAMSP4096X16WDX2
XWD_I170 BPGEN DBL NXP0_2 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_171 WL1_171
+  RAMSP4096X16WDX2
XWD_I171 BPGEN DBL NXP0_2 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_172 WL1_172
+  RAMSP4096X16WDX2
XWD_I172 BPGEN DBL NXP0_3 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_173 WL1_173
+  RAMSP4096X16WDX2
XWD_I173 BPGEN DBL NXP0_3 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_174 WL1_174
+  RAMSP4096X16WDX2
XWD_I174 BPGEN DBL NXP0_3 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_175 WL1_175
+  RAMSP4096X16WDX2
XWD_I175 BPGEN DBL NXP0_3 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_176 WL1_176
+  RAMSP4096X16WDX2
XWD_I176 BPGEN DBL NXP0_4 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_177 WL1_177
+  RAMSP4096X16WDX2
XWD_I177 BPGEN DBL NXP0_4 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_178 WL1_178
+  RAMSP4096X16WDX2
XWD_I178 BPGEN DBL NXP0_4 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_179 WL1_179
+  RAMSP4096X16WDX2
XWD_I179 BPGEN DBL NXP0_4 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_180 WL1_180
+  RAMSP4096X16WDX2
XWD_I18 BPGEN DBL NXP0_4 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_19 WL1_19
+  RAMSP4096X16WDX2
XWD_I180 BPGEN DBL NXP0_5 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_181 WL1_181
+  RAMSP4096X16WDX2
XWD_I181 BPGEN DBL NXP0_5 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_182 WL1_182
+  RAMSP4096X16WDX2
XWD_I182 BPGEN DBL NXP0_5 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_183 WL1_183
+  RAMSP4096X16WDX2
XWD_I183 BPGEN DBL NXP0_5 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_184 WL1_184
+  RAMSP4096X16WDX2
XWD_I184 BPGEN DBL NXP0_6 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_185 WL1_185
+  RAMSP4096X16WDX2
XWD_I185 BPGEN DBL NXP0_6 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_186 WL1_186
+  RAMSP4096X16WDX2
XWD_I186 BPGEN DBL NXP0_6 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_187 WL1_187
+  RAMSP4096X16WDX2
XWD_I187 BPGEN DBL NXP0_6 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_188 WL1_188
+  RAMSP4096X16WDX2
XWD_I188 BPGEN DBL NXP0_7 NXP1_6 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_189 WL1_189
+  RAMSP4096X16WDX2
XWD_I189 BPGEN DBL NXP0_7 NXP1_6 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_190 WL1_190
+  RAMSP4096X16WDX2
XWD_I19 BPGEN DBL NXP0_4 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_20 WL1_20
+  RAMSP4096X16WDX2
XWD_I190 BPGEN DBL NXP0_7 NXP1_6 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_191 WL1_191
+  RAMSP4096X16WDX2
XWD_I191 BPGEN DBL NXP0_7 NXP1_6 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_192 WL1_192
+  RAMSP4096X16WDX2
XWD_I192 BPGEN DBL NXP0_0 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_193 WL1_193
+  RAMSP4096X16WDX2
XWD_I193 BPGEN DBL NXP0_0 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_194 WL1_194
+  RAMSP4096X16WDX2
XWD_I194 BPGEN DBL NXP0_0 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_195 WL1_195
+  RAMSP4096X16WDX2
XWD_I195 BPGEN DBL NXP0_0 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_196 WL1_196
+  RAMSP4096X16WDX2
XWD_I196 BPGEN DBL NXP0_1 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_197 WL1_197
+  RAMSP4096X16WDX2
XWD_I197 BPGEN DBL NXP0_1 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_198 WL1_198
+  RAMSP4096X16WDX2
XWD_I198 BPGEN DBL NXP0_1 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_199 WL1_199
+  RAMSP4096X16WDX2
XWD_I199 BPGEN DBL NXP0_1 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_200 WL1_200
+  RAMSP4096X16WDX2
XWD_I2 BPGEN DBL NXP0_0 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_3 WL1_3 RAMSP4096X16WDX2
XWD_I20 BPGEN DBL NXP0_5 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_21 WL1_21
+  RAMSP4096X16WDX2
XWD_I200 BPGEN DBL NXP0_2 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_201 WL1_201
+  RAMSP4096X16WDX2
XWD_I201 BPGEN DBL NXP0_2 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_202 WL1_202
+  RAMSP4096X16WDX2
XWD_I202 BPGEN DBL NXP0_2 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_203 WL1_203
+  RAMSP4096X16WDX2
XWD_I203 BPGEN DBL NXP0_2 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_204 WL1_204
+  RAMSP4096X16WDX2
XWD_I204 BPGEN DBL NXP0_3 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_205 WL1_205
+  RAMSP4096X16WDX2
XWD_I205 BPGEN DBL NXP0_3 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_206 WL1_206
+  RAMSP4096X16WDX2
XWD_I206 BPGEN DBL NXP0_3 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_207 WL1_207
+  RAMSP4096X16WDX2
XWD_I207 BPGEN DBL NXP0_3 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_208 WL1_208
+  RAMSP4096X16WDX2
XWD_I208 BPGEN DBL NXP0_4 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_209 WL1_209
+  RAMSP4096X16WDX2
XWD_I209 BPGEN DBL NXP0_4 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_210 WL1_210
+  RAMSP4096X16WDX2
XWD_I21 BPGEN DBL NXP0_5 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_22 WL1_22
+  RAMSP4096X16WDX2
XWD_I210 BPGEN DBL NXP0_4 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_211 WL1_211
+  RAMSP4096X16WDX2
XWD_I211 BPGEN DBL NXP0_4 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_212 WL1_212
+  RAMSP4096X16WDX2
XWD_I212 BPGEN DBL NXP0_5 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_213 WL1_213
+  RAMSP4096X16WDX2
XWD_I213 BPGEN DBL NXP0_5 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_214 WL1_214
+  RAMSP4096X16WDX2
XWD_I214 BPGEN DBL NXP0_5 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_215 WL1_215
+  RAMSP4096X16WDX2
XWD_I215 BPGEN DBL NXP0_5 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_216 WL1_216
+  RAMSP4096X16WDX2
XWD_I216 BPGEN DBL NXP0_6 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_217 WL1_217
+  RAMSP4096X16WDX2
XWD_I217 BPGEN DBL NXP0_6 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_218 WL1_218
+  RAMSP4096X16WDX2
XWD_I218 BPGEN DBL NXP0_6 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_219 WL1_219
+  RAMSP4096X16WDX2
XWD_I219 BPGEN DBL NXP0_6 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_220 WL1_220
+  RAMSP4096X16WDX2
XWD_I22 BPGEN DBL NXP0_5 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_23 WL1_23
+  RAMSP4096X16WDX2
XWD_I220 BPGEN DBL NXP0_7 NXP1_7 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_221 WL1_221
+  RAMSP4096X16WDX2
XWD_I221 BPGEN DBL NXP0_7 NXP1_7 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_222 WL1_222
+  RAMSP4096X16WDX2
XWD_I222 BPGEN DBL NXP0_7 NXP1_7 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_223 WL1_223
+  RAMSP4096X16WDX2
XWD_I23 BPGEN DBL NXP0_5 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_24 WL1_24
+  RAMSP4096X16WDX2
XWD_I24 BPGEN DBL NXP0_6 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_25 WL1_25
+  RAMSP4096X16WDX2
XWD_I25 BPGEN DBL NXP0_6 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_26 WL1_26
+  RAMSP4096X16WDX2
XWD_I26 BPGEN DBL NXP0_6 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_27 WL1_27
+  RAMSP4096X16WDX2
XWD_I27 BPGEN DBL NXP0_6 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_28 WL1_28
+  RAMSP4096X16WDX2
XWD_I28 BPGEN DBL NXP0_7 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_29 WL1_29
+  RAMSP4096X16WDX2
XWD_I29 BPGEN DBL NXP0_7 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_30 WL1_30
+  RAMSP4096X16WDX2
XWD_I3 BPGEN DBL NXP0_0 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_4 WL1_4 RAMSP4096X16WDX2
XWD_I30 BPGEN DBL NXP0_7 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_31 WL1_31
+  RAMSP4096X16WDX2
XWD_I31 BPGEN DBL NXP0_7 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_32 WL1_32
+  RAMSP4096X16WDX2
XWD_I32 BPGEN DBL NXP0_0 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_33 WL1_33
+  RAMSP4096X16WDX2
XWD_I33 BPGEN DBL NXP0_0 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_34 WL1_34
+  RAMSP4096X16WDX2
XWD_I34 BPGEN DBL NXP0_0 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_35 WL1_35
+  RAMSP4096X16WDX2
XWD_I35 BPGEN DBL NXP0_0 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_36 WL1_36
+  RAMSP4096X16WDX2
XWD_I36 BPGEN DBL NXP0_1 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_37 WL1_37
+  RAMSP4096X16WDX2
XWD_I37 BPGEN DBL NXP0_1 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_38 WL1_38
+  RAMSP4096X16WDX2
XWD_I38 BPGEN DBL NXP0_1 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_39 WL1_39
+  RAMSP4096X16WDX2
XWD_I39 BPGEN DBL NXP0_1 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_40 WL1_40
+  RAMSP4096X16WDX2
XWD_I4 BPGEN DBL NXP0_1 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_5 WL1_5 RAMSP4096X16WDX2
XWD_I40 BPGEN DBL NXP0_2 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_41 WL1_41
+  RAMSP4096X16WDX2
XWD_I41 BPGEN DBL NXP0_2 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_42 WL1_42
+  RAMSP4096X16WDX2
XWD_I42 BPGEN DBL NXP0_2 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_43 WL1_43
+  RAMSP4096X16WDX2
XWD_I43 BPGEN DBL NXP0_2 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_44 WL1_44
+  RAMSP4096X16WDX2
XWD_I44 BPGEN DBL NXP0_3 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_45 WL1_45
+  RAMSP4096X16WDX2
XWD_I45 BPGEN DBL NXP0_3 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_46 WL1_46
+  RAMSP4096X16WDX2
XWD_I46 BPGEN DBL NXP0_3 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_47 WL1_47
+  RAMSP4096X16WDX2
XWD_I47 BPGEN DBL NXP0_3 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_48 WL1_48
+  RAMSP4096X16WDX2
XWD_I48 BPGEN DBL NXP0_4 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_49 WL1_49
+  RAMSP4096X16WDX2
XWD_I49 BPGEN DBL NXP0_4 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_50 WL1_50
+  RAMSP4096X16WDX2
XWD_I5 BPGEN DBL NXP0_1 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_6 WL1_6 RAMSP4096X16WDX2
XWD_I50 BPGEN DBL NXP0_4 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_51 WL1_51
+  RAMSP4096X16WDX2
XWD_I51 BPGEN DBL NXP0_4 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_52 WL1_52
+  RAMSP4096X16WDX2
XWD_I52 BPGEN DBL NXP0_5 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_53 WL1_53
+  RAMSP4096X16WDX2
XWD_I53 BPGEN DBL NXP0_5 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_54 WL1_54
+  RAMSP4096X16WDX2
XWD_I54 BPGEN DBL NXP0_5 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_55 WL1_55
+  RAMSP4096X16WDX2
XWD_I55 BPGEN DBL NXP0_5 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_56 WL1_56
+  RAMSP4096X16WDX2
XWD_I56 BPGEN DBL NXP0_6 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_57 WL1_57
+  RAMSP4096X16WDX2
XWD_I57 BPGEN DBL NXP0_6 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_58 WL1_58
+  RAMSP4096X16WDX2
XWD_I58 BPGEN DBL NXP0_6 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_59 WL1_59
+  RAMSP4096X16WDX2
XWD_I59 BPGEN DBL NXP0_6 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_60 WL1_60
+  RAMSP4096X16WDX2
XWD_I6 BPGEN DBL NXP0_1 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_7 WL1_7 RAMSP4096X16WDX2
XWD_I60 BPGEN DBL NXP0_7 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_61 WL1_61
+  RAMSP4096X16WDX2
XWD_I61 BPGEN DBL NXP0_7 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_62 WL1_62
+  RAMSP4096X16WDX2
XWD_I62 BPGEN DBL NXP0_7 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_63 WL1_63
+  RAMSP4096X16WDX2
XWD_I63 BPGEN DBL NXP0_7 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_64 WL1_64
+  RAMSP4096X16WDX2
XWD_I64 BPGEN DBL NXP0_0 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_65 WL1_65
+  RAMSP4096X16WDX2
XWD_I65 BPGEN DBL NXP0_0 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_66 WL1_66
+  RAMSP4096X16WDX2
XWD_I66 BPGEN DBL NXP0_0 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_67 WL1_67
+  RAMSP4096X16WDX2
XWD_I67 BPGEN DBL NXP0_0 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_68 WL1_68
+  RAMSP4096X16WDX2
XWD_I68 BPGEN DBL NXP0_1 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_69 WL1_69
+  RAMSP4096X16WDX2
XWD_I69 BPGEN DBL NXP0_1 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_70 WL1_70
+  RAMSP4096X16WDX2
XWD_I7 BPGEN DBL NXP0_1 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_8 WL1_8 RAMSP4096X16WDX2
XWD_I70 BPGEN DBL NXP0_1 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_71 WL1_71
+  RAMSP4096X16WDX2
XWD_I71 BPGEN DBL NXP0_1 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_72 WL1_72
+  RAMSP4096X16WDX2
XWD_I72 BPGEN DBL NXP0_2 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_73 WL1_73
+  RAMSP4096X16WDX2
XWD_I73 BPGEN DBL NXP0_2 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_74 WL1_74
+  RAMSP4096X16WDX2
XWD_I74 BPGEN DBL NXP0_2 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_75 WL1_75
+  RAMSP4096X16WDX2
XWD_I75 BPGEN DBL NXP0_2 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_76 WL1_76
+  RAMSP4096X16WDX2
XWD_I76 BPGEN DBL NXP0_3 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_77 WL1_77
+  RAMSP4096X16WDX2
XWD_I77 BPGEN DBL NXP0_3 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_78 WL1_78
+  RAMSP4096X16WDX2
XWD_I78 BPGEN DBL NXP0_3 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_79 WL1_79
+  RAMSP4096X16WDX2
XWD_I79 BPGEN DBL NXP0_3 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_80 WL1_80
+  RAMSP4096X16WDX2
XWD_I8 BPGEN DBL NXP0_2 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_9 WL1_9 RAMSP4096X16WDX2
XWD_I80 BPGEN DBL NXP0_4 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_81 WL1_81
+  RAMSP4096X16WDX2
XWD_I81 BPGEN DBL NXP0_4 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_82 WL1_82
+  RAMSP4096X16WDX2
XWD_I82 BPGEN DBL NXP0_4 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_83 WL1_83
+  RAMSP4096X16WDX2
XWD_I83 BPGEN DBL NXP0_4 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_84 WL1_84
+  RAMSP4096X16WDX2
XWD_I84 BPGEN DBL NXP0_5 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_85 WL1_85
+  RAMSP4096X16WDX2
XWD_I85 BPGEN DBL NXP0_5 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_86 WL1_86
+  RAMSP4096X16WDX2
XWD_I86 BPGEN DBL NXP0_5 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_87 WL1_87
+  RAMSP4096X16WDX2
XWD_I87 BPGEN DBL NXP0_5 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_88 WL1_88
+  RAMSP4096X16WDX2
XWD_I88 BPGEN DBL NXP0_6 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_89 WL1_89
+  RAMSP4096X16WDX2
XWD_I89 BPGEN DBL NXP0_6 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_90 WL1_90
+  RAMSP4096X16WDX2
XWD_I9 BPGEN DBL NXP0_2 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_10 WL1_10
+  RAMSP4096X16WDX2
XWD_I90 BPGEN DBL NXP0_6 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_91 WL1_91
+  RAMSP4096X16WDX2
XWD_I91 BPGEN DBL NXP0_6 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_92 WL1_92
+  RAMSP4096X16WDX2
XWD_I92 BPGEN DBL NXP0_7 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_93 WL1_93
+  RAMSP4096X16WDX2
XWD_I93 BPGEN DBL NXP0_7 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_94 WL1_94
+  RAMSP4096X16WDX2
XWD_I94 BPGEN DBL NXP0_7 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_95 WL1_95
+  RAMSP4096X16WDX2
XWD_I95 BPGEN DBL NXP0_7 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_96 WL1_96
+  RAMSP4096X16WDX2
XWD_I96 BPGEN DBL NXP0_0 NXP1_4 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_97 WL1_97
+  RAMSP4096X16WDX2
XWD_I97 BPGEN DBL NXP0_0 NXP1_4 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_98 WL1_98
+  RAMSP4096X16WDX2
XWD_I98 BPGEN DBL NXP0_0 NXP1_4 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_99 WL1_99
+  RAMSP4096X16WDX2
XWD_I99 BPGEN DBL NXP0_0 NXP1_4 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_100 WL1_100
+  RAMSP4096X16WDX2
XWD_TOP BPGEN DBL NXP0_7 NXP1_7 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_224 WL1_224
+  RAMSP4096X16WDX2
XWL_CAP BPGEN BRET1N BRET2N DBL LOG0_DWL NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7
+  NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1
+  NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET_0 ROWCLK0 ROWCLK1 ROWCLK2
+  ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC VDDC_LEFT VDDC_RIGHT VNWC VDDP
+  VDDPE VNWC VNWP VSSE VSSE VSSE RAMSP4096X16WDTOP_WDX64
.ENDS RAMSP4096X16WDDRVCOL
****
.SUBCKT RAMSP4096X16MEM_SLICE A[0] A[1] A[2] A[3] A[4] A[5] BL[0]_0 BL[0]_1
+  BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10
+  BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18
+  BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26
+  BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4
+  BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13
+  BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21
+  BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29
+  BL[2]_30 BL[2]_31 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6
+  BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14
+  BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22
+  BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30
+  BL[3]_31 BPGEN BRET1N BRET2N DBL DWL EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACT_CC NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11
+  NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18
+  NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25
+  NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8
+  NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15
+  NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22
+  NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29
+  NBL[3]_30 NBL[3]_31 NGWE RET_0 RET_1 SAE_DUMMY VDDC VDDP VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VNWP_0 VNWP_1 VNWP_2
+  VNWP_3 VNWP_4 VPW
** RAMSP4096X16MEM_SLICE: 404191 flat devices **
XMEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDC
+  VNWP_0 VNWP_1 VPW WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6
+  WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14
+  WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22
+  WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30
+  WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38
+  WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46
+  WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54
+  WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62
+  WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70
+  WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78
+  WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86
+  WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94
+  WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102
+  WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109
+  WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[0]_116
+  WL[0]_117 WL[0]_118 WL[0]_119 WL[0]_120 WL[0]_121 WL[0]_122 WL[0]_123
+  WL[0]_124 WL[0]_125 WL[0]_126 WL[0]_127 WL[0]_128 WL[0]_129 WL[0]_130
+  WL[0]_131 WL[0]_132 WL[0]_133 WL[0]_134 WL[0]_135 WL[0]_136 WL[0]_137
+  WL[0]_138 WL[0]_139 WL[0]_140 WL[0]_141 WL[0]_142 WL[0]_143 WL[0]_144
+  WL[0]_145 WL[0]_146 WL[0]_147 WL[0]_148 WL[0]_149 WL[0]_150 WL[0]_151
+  WL[0]_152 WL[0]_153 WL[0]_154 WL[0]_155 WL[0]_156 WL[0]_157 WL[0]_158
+  WL[0]_159 WL[0]_160 WL[0]_161 WL[0]_162 WL[0]_163 WL[0]_164 WL[0]_165
+  WL[0]_166 WL[0]_167 WL[0]_168 WL[0]_169 WL[0]_170 WL[0]_171 WL[0]_172
+  WL[0]_173 WL[0]_174 WL[0]_175 WL[0]_176 WL[0]_177 WL[0]_178 WL[0]_179
+  WL[0]_180 WL[0]_181 WL[0]_182 WL[0]_183 WL[0]_184 WL[0]_185 WL[0]_186
+  WL[0]_187 WL[0]_188 WL[0]_189 WL[0]_190 WL[0]_191 WL[0]_192 WL[0]_193
+  WL[0]_194 WL[0]_195 WL[0]_196 WL[0]_197 WL[0]_198 WL[0]_199 WL[0]_200
+  WL[0]_201 WL[0]_202 WL[0]_203 WL[0]_204 WL[0]_205 WL[0]_206 WL[0]_207
+  WL[0]_208 WL[0]_209 WL[0]_210 WL[0]_211 WL[0]_212 WL[0]_213 WL[0]_214
+  WL[0]_215 WL[0]_216 WL[0]_217 WL[0]_218 WL[0]_219 WL[0]_220 WL[0]_221
+  WL[0]_222 WL[0]_223 WL[0]_224 WL[0]_225 WL[0]_226 WL[0]_227 WL[0]_228
+  WL[0]_229 WL[0]_230 WL[0]_231 WL[0]_232 WL[0]_233 WL[0]_234 WL[0]_235
+  WL[0]_236 WL[0]_237 WL[0]_238 WL[0]_239 WL[0]_240 WL[0]_241 WL[0]_242
+  WL[0]_243 WL[0]_244 WL[0]_245 WL[0]_246 WL[0]_247 WL[0]_248 WL[0]_249
+  WL[0]_250 WL[0]_251 WL[0]_252 WL[0]_253 WL[0]_254 WL[0]_255 WL[1]_0 WL[1]_1
+  WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10
+  WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18
+  WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26
+  WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32 WL[1]_33 WL[1]_34
+  WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41 WL[1]_42
+  WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49 WL[1]_50
+  WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57 WL[1]_58
+  WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65 WL[1]_66
+  WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73 WL[1]_74
+  WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81 WL[1]_82
+  WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89 WL[1]_90
+  WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97 WL[1]_98
+  WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103 WL[1]_104 WL[1]_105
+  WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110 WL[1]_111 WL[1]_112
+  WL[1]_113 WL[1]_114 WL[1]_115 WL[1]_116 WL[1]_117 WL[1]_118 WL[1]_119
+  WL[1]_120 WL[1]_121 WL[1]_122 WL[1]_123 WL[1]_124 WL[1]_125 WL[1]_126
+  WL[1]_127 WL[1]_128 WL[1]_129 WL[1]_130 WL[1]_131 WL[1]_132 WL[1]_133
+  WL[1]_134 WL[1]_135 WL[1]_136 WL[1]_137 WL[1]_138 WL[1]_139 WL[1]_140
+  WL[1]_141 WL[1]_142 WL[1]_143 WL[1]_144 WL[1]_145 WL[1]_146 WL[1]_147
+  WL[1]_148 WL[1]_149 WL[1]_150 WL[1]_151 WL[1]_152 WL[1]_153 WL[1]_154
+  WL[1]_155 WL[1]_156 WL[1]_157 WL[1]_158 WL[1]_159 WL[1]_160 WL[1]_161
+  WL[1]_162 WL[1]_163 WL[1]_164 WL[1]_165 WL[1]_166 WL[1]_167 WL[1]_168
+  WL[1]_169 WL[1]_170 WL[1]_171 WL[1]_172 WL[1]_173 WL[1]_174 WL[1]_175
+  WL[1]_176 WL[1]_177 WL[1]_178 WL[1]_179 WL[1]_180 WL[1]_181 WL[1]_182
+  WL[1]_183 WL[1]_184 WL[1]_185 WL[1]_186 WL[1]_187 WL[1]_188 WL[1]_189
+  WL[1]_190 WL[1]_191 WL[1]_192 WL[1]_193 WL[1]_194 WL[1]_195 WL[1]_196
+  WL[1]_197 WL[1]_198 WL[1]_199 WL[1]_200 WL[1]_201 WL[1]_202 WL[1]_203
+  WL[1]_204 WL[1]_205 WL[1]_206 WL[1]_207 WL[1]_208 WL[1]_209 WL[1]_210
+  WL[1]_211 WL[1]_212 WL[1]_213 WL[1]_214 WL[1]_215 WL[1]_216 WL[1]_217
+  WL[1]_218 WL[1]_219 WL[1]_220 WL[1]_221 WL[1]_222 WL[1]_223 WL[1]_224
+  WL[1]_225 WL[1]_226 WL[1]_227 WL[1]_228 WL[1]_229 WL[1]_230 WL[1]_231
+  WL[1]_232 WL[1]_233 WL[1]_234 WL[1]_235 WL[1]_236 WL[1]_237 WL[1]_238
+  WL[1]_239 WL[1]_240 WL[1]_241 WL[1]_242 WL[1]_243 WL[1]_244 WL[1]_245
+  WL[1]_246 WL[1]_247 WL[1]_248 WL[1]_249 WL[1]_250 WL[1]_251 WL[1]_252
+  WL[1]_253 WL[1]_254 WL[1]_255 RAMSP4096X16MEMCORE_L
XMEMCORE_R BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22
+  BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30
+  BL[1]_31 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22
+  BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30
+  BL[2]_31 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22
+  BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30
+  BL[3]_31 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21
+  NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28
+  NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[2]_16 NBL[2]_17
+  NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24
+  NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31
+  NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22
+  NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29
+  NBL[3]_30 NBL[3]_31 VDDC VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VNWP_3 VNWP_4 VPW WL[0]_0 WL[0]_1 WL[0]_2
+  WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11
+  WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19
+  WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27
+  WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35
+  WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43
+  WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51
+  WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59
+  WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67
+  WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75
+  WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83
+  WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91
+  WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99
+  WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106
+  WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113
+  WL[0]_114 WL[0]_115 WL[0]_116 WL[0]_117 WL[0]_118 WL[0]_119 WL[0]_120
+  WL[0]_121 WL[0]_122 WL[0]_123 WL[0]_124 WL[0]_125 WL[0]_126 WL[0]_127
+  WL[0]_128 WL[0]_129 WL[0]_130 WL[0]_131 WL[0]_132 WL[0]_133 WL[0]_134
+  WL[0]_135 WL[0]_136 WL[0]_137 WL[0]_138 WL[0]_139 WL[0]_140 WL[0]_141
+  WL[0]_142 WL[0]_143 WL[0]_144 WL[0]_145 WL[0]_146 WL[0]_147 WL[0]_148
+  WL[0]_149 WL[0]_150 WL[0]_151 WL[0]_152 WL[0]_153 WL[0]_154 WL[0]_155
+  WL[0]_156 WL[0]_157 WL[0]_158 WL[0]_159 WL[0]_160 WL[0]_161 WL[0]_162
+  WL[0]_163 WL[0]_164 WL[0]_165 WL[0]_166 WL[0]_167 WL[0]_168 WL[0]_169
+  WL[0]_170 WL[0]_171 WL[0]_172 WL[0]_173 WL[0]_174 WL[0]_175 WL[0]_176
+  WL[0]_177 WL[0]_178 WL[0]_179 WL[0]_180 WL[0]_181 WL[0]_182 WL[0]_183
+  WL[0]_184 WL[0]_185 WL[0]_186 WL[0]_187 WL[0]_188 WL[0]_189 WL[0]_190
+  WL[0]_191 WL[0]_192 WL[0]_193 WL[0]_194 WL[0]_195 WL[0]_196 WL[0]_197
+  WL[0]_198 WL[0]_199 WL[0]_200 WL[0]_201 WL[0]_202 WL[0]_203 WL[0]_204
+  WL[0]_205 WL[0]_206 WL[0]_207 WL[0]_208 WL[0]_209 WL[0]_210 WL[0]_211
+  WL[0]_212 WL[0]_213 WL[0]_214 WL[0]_215 WL[0]_216 WL[0]_217 WL[0]_218
+  WL[0]_219 WL[0]_220 WL[0]_221 WL[0]_222 WL[0]_223 WL[0]_224 WL[0]_225
+  WL[0]_226 WL[0]_227 WL[0]_228 WL[0]_229 WL[0]_230 WL[0]_231 WL[0]_232
+  WL[0]_233 WL[0]_234 WL[0]_235 WL[0]_236 WL[0]_237 WL[0]_238 WL[0]_239
+  WL[0]_240 WL[0]_241 WL[0]_242 WL[0]_243 WL[0]_244 WL[0]_245 WL[0]_246
+  WL[0]_247 WL[0]_248 WL[0]_249 WL[0]_250 WL[0]_251 WL[0]_252 WL[0]_253
+  WL[0]_254 WL[0]_255 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6
+  WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14
+  WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22
+  WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30
+  WL[1]_31 WL[1]_32 WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38
+  WL[1]_39 WL[1]_40 WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46
+  WL[1]_47 WL[1]_48 WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54
+  WL[1]_55 WL[1]_56 WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62
+  WL[1]_63 WL[1]_64 WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70
+  WL[1]_71 WL[1]_72 WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78
+  WL[1]_79 WL[1]_80 WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86
+  WL[1]_87 WL[1]_88 WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94
+  WL[1]_95 WL[1]_96 WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102
+  WL[1]_103 WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109
+  WL[1]_110 WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115 WL[1]_116
+  WL[1]_117 WL[1]_118 WL[1]_119 WL[1]_120 WL[1]_121 WL[1]_122 WL[1]_123
+  WL[1]_124 WL[1]_125 WL[1]_126 WL[1]_127 WL[1]_128 WL[1]_129 WL[1]_130
+  WL[1]_131 WL[1]_132 WL[1]_133 WL[1]_134 WL[1]_135 WL[1]_136 WL[1]_137
+  WL[1]_138 WL[1]_139 WL[1]_140 WL[1]_141 WL[1]_142 WL[1]_143 WL[1]_144
+  WL[1]_145 WL[1]_146 WL[1]_147 WL[1]_148 WL[1]_149 WL[1]_150 WL[1]_151
+  WL[1]_152 WL[1]_153 WL[1]_154 WL[1]_155 WL[1]_156 WL[1]_157 WL[1]_158
+  WL[1]_159 WL[1]_160 WL[1]_161 WL[1]_162 WL[1]_163 WL[1]_164 WL[1]_165
+  WL[1]_166 WL[1]_167 WL[1]_168 WL[1]_169 WL[1]_170 WL[1]_171 WL[1]_172
+  WL[1]_173 WL[1]_174 WL[1]_175 WL[1]_176 WL[1]_177 WL[1]_178 WL[1]_179
+  WL[1]_180 WL[1]_181 WL[1]_182 WL[1]_183 WL[1]_184 WL[1]_185 WL[1]_186
+  WL[1]_187 WL[1]_188 WL[1]_189 WL[1]_190 WL[1]_191 WL[1]_192 WL[1]_193
+  WL[1]_194 WL[1]_195 WL[1]_196 WL[1]_197 WL[1]_198 WL[1]_199 WL[1]_200
+  WL[1]_201 WL[1]_202 WL[1]_203 WL[1]_204 WL[1]_205 WL[1]_206 WL[1]_207
+  WL[1]_208 WL[1]_209 WL[1]_210 WL[1]_211 WL[1]_212 WL[1]_213 WL[1]_214
+  WL[1]_215 WL[1]_216 WL[1]_217 WL[1]_218 WL[1]_219 WL[1]_220 WL[1]_221
+  WL[1]_222 WL[1]_223 WL[1]_224 WL[1]_225 WL[1]_226 WL[1]_227 WL[1]_228
+  WL[1]_229 WL[1]_230 WL[1]_231 WL[1]_232 WL[1]_233 WL[1]_234 WL[1]_235
+  WL[1]_236 WL[1]_237 WL[1]_238 WL[1]_239 WL[1]_240 WL[1]_241 WL[1]_242
+  WL[1]_243 WL[1]_244 WL[1]_245 WL[1]_246 WL[1]_247 WL[1]_248 WL[1]_249
+  WL[1]_250 WL[1]_251 WL[1]_252 WL[1]_253 WL[1]_254 WL[1]_255
+  RAMSP4096X16MEMCORE_R
XWDDRVCOL A[0] A[1] A[2] A[3] A[4] A[5] BPGEN BRET1N BRET2N DBL DWL EMA0 EMA1
+  EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACT_CC
+  NGWE RET_0 RET_1 SAE_DUMMY VDDC VDDC VDDP VDDPE_16 VDDC VNWP_2 VPW WL[0]_0
+  WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39
+  WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47
+  WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55
+  WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63
+  WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71
+  WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79
+  WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87
+  WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95
+  WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103
+  WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110
+  WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[0]_116 WL[0]_117
+  WL[0]_118 WL[0]_119 WL[0]_120 WL[0]_121 WL[0]_122 WL[0]_123 WL[0]_124
+  WL[0]_125 WL[0]_126 WL[0]_127 WL[0]_128 WL[0]_129 WL[0]_130 WL[0]_131
+  WL[0]_132 WL[0]_133 WL[0]_134 WL[0]_135 WL[0]_136 WL[0]_137 WL[0]_138
+  WL[0]_139 WL[0]_140 WL[0]_141 WL[0]_142 WL[0]_143 WL[0]_144 WL[0]_145
+  WL[0]_146 WL[0]_147 WL[0]_148 WL[0]_149 WL[0]_150 WL[0]_151 WL[0]_152
+  WL[0]_153 WL[0]_154 WL[0]_155 WL[0]_156 WL[0]_157 WL[0]_158 WL[0]_159
+  WL[0]_160 WL[0]_161 WL[0]_162 WL[0]_163 WL[0]_164 WL[0]_165 WL[0]_166
+  WL[0]_167 WL[0]_168 WL[0]_169 WL[0]_170 WL[0]_171 WL[0]_172 WL[0]_173
+  WL[0]_174 WL[0]_175 WL[0]_176 WL[0]_177 WL[0]_178 WL[0]_179 WL[0]_180
+  WL[0]_181 WL[0]_182 WL[0]_183 WL[0]_184 WL[0]_185 WL[0]_186 WL[0]_187
+  WL[0]_188 WL[0]_189 WL[0]_190 WL[0]_191 WL[0]_192 WL[0]_193 WL[0]_194
+  WL[0]_195 WL[0]_196 WL[0]_197 WL[0]_198 WL[0]_199 WL[0]_200 WL[0]_201
+  WL[0]_202 WL[0]_203 WL[0]_204 WL[0]_205 WL[0]_206 WL[0]_207 WL[0]_208
+  WL[0]_209 WL[0]_210 WL[0]_211 WL[0]_212 WL[0]_213 WL[0]_214 WL[0]_215
+  WL[0]_216 WL[0]_217 WL[0]_218 WL[0]_219 WL[0]_220 WL[0]_221 WL[0]_222
+  WL[0]_223 WL[0]_224 WL[0]_225 WL[0]_226 WL[0]_227 WL[0]_228 WL[0]_229
+  WL[0]_230 WL[0]_231 WL[0]_232 WL[0]_233 WL[0]_234 WL[0]_235 WL[0]_236
+  WL[0]_237 WL[0]_238 WL[0]_239 WL[0]_240 WL[0]_241 WL[0]_242 WL[0]_243
+  WL[0]_244 WL[0]_245 WL[0]_246 WL[0]_247 WL[0]_248 WL[0]_249 WL[0]_250
+  WL[0]_251 WL[0]_252 WL[0]_253 WL[0]_254 WL[0]_255 WL[1]_0 WL[1]_32 WL[1]_33
+  WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41
+  WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49
+  WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57
+  WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65
+  WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73
+  WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81
+  WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89
+  WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97
+  WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103 WL[1]_104
+  WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110 WL[1]_111
+  WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115 WL[1]_116 WL[1]_117 WL[1]_118
+  WL[1]_119 WL[1]_120 WL[1]_121 WL[1]_122 WL[1]_123 WL[1]_124 WL[1]_125
+  WL[1]_126 WL[1]_127 WL[1]_128 WL[1]_129 WL[1]_130 WL[1]_131 WL[1]_132
+  WL[1]_133 WL[1]_134 WL[1]_135 WL[1]_136 WL[1]_137 WL[1]_138 WL[1]_139
+  WL[1]_140 WL[1]_141 WL[1]_142 WL[1]_143 WL[1]_144 WL[1]_145 WL[1]_146
+  WL[1]_147 WL[1]_148 WL[1]_149 WL[1]_150 WL[1]_151 WL[1]_152 WL[1]_153
+  WL[1]_154 WL[1]_155 WL[1]_156 WL[1]_157 WL[1]_158 WL[1]_159 WL[1]_160
+  WL[1]_161 WL[1]_162 WL[1]_163 WL[1]_164 WL[1]_165 WL[1]_166 WL[1]_167
+  WL[1]_168 WL[1]_169 WL[1]_170 WL[1]_171 WL[1]_172 WL[1]_173 WL[1]_174
+  WL[1]_175 WL[1]_176 WL[1]_177 WL[1]_178 WL[1]_179 WL[1]_180 WL[1]_181
+  WL[1]_182 WL[1]_183 WL[1]_184 WL[1]_185 WL[1]_186 WL[1]_187 WL[1]_188
+  WL[1]_189 WL[1]_190 WL[1]_191 WL[1]_192 WL[1]_193 WL[1]_194 WL[1]_195
+  WL[1]_196 WL[1]_197 WL[1]_198 WL[1]_199 WL[1]_200 WL[1]_201 WL[1]_202
+  WL[1]_203 WL[1]_204 WL[1]_205 WL[1]_206 WL[1]_207 WL[1]_208 WL[1]_209
+  WL[1]_210 WL[1]_211 WL[1]_212 WL[1]_213 WL[1]_214 WL[1]_215 WL[1]_216
+  WL[1]_217 WL[1]_218 WL[1]_219 WL[1]_220 WL[1]_221 WL[1]_222 WL[1]_223
+  WL[1]_224 WL[1]_225 WL[1]_226 WL[1]_227 WL[1]_228 WL[1]_229 WL[1]_230
+  WL[1]_231 WL[1]_232 WL[1]_233 WL[1]_234 WL[1]_235 WL[1]_236 WL[1]_237
+  WL[1]_238 WL[1]_239 WL[1]_240 WL[1]_241 WL[1]_242 WL[1]_243 WL[1]_244
+  WL[1]_245 WL[1]_246 WL[1]_247 WL[1]_248 WL[1]_249 WL[1]_250 WL[1]_251
+  WL[1]_252 WL[1]_253 WL[1]_254 WL[1]_255 WL[0]_1 WL[1]_1 WL[0]_2 WL[1]_2
+  WL[0]_3 WL[1]_3 WL[0]_4 WL[1]_4 WL[0]_5 WL[1]_5 WL[0]_6 WL[1]_6 WL[0]_7
+  WL[1]_7 WL[0]_8 WL[1]_8 WL[0]_9 WL[1]_9 WL[0]_10 WL[1]_10 WL[0]_11 WL[1]_11
+  WL[0]_12 WL[1]_12 WL[0]_13 WL[1]_13 WL[0]_14 WL[1]_14 WL[0]_15 WL[1]_15
+  WL[0]_16 WL[1]_16 WL[0]_17 WL[1]_17 WL[0]_18 WL[1]_18 WL[0]_19 WL[1]_19
+  WL[0]_20 WL[1]_20 WL[0]_21 WL[1]_21 WL[0]_22 WL[1]_22 WL[0]_23 WL[1]_23
+  WL[0]_24 WL[1]_24 WL[0]_25 WL[1]_25 WL[0]_26 WL[1]_26 WL[0]_27 WL[1]_27
+  WL[0]_28 WL[1]_28 WL[0]_29 WL[1]_29 WL[0]_30 WL[1]_30 WL[0]_31 WL[1]_31
+  RAMSP4096X16WDDRVCOL
.ENDS RAMSP4096X16MEM_SLICE
****
.SUBCKT RAMSP4096X16TILE_TOP CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2
+  DFTRAMBYP D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14
+  D_15 EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5
+  FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1
+  LA2 LAY0 LAY1 LAY2 PEN PENSI PENSO PSO0 PSO1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6
+  Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RET1N SO0 SO1 TEN TPEN VDDC_L VDDPE VPW WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10 WENY_11
+  WENY_12 WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6
+  WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMSP4096X16TILE_TOP: 410196 flat devices **
XBOTCAP CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP
+  DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7
+  D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 DFTRAMBYP NWCLK
+  PEN PENSI PENSO DFTRAMBYP DFTRAMBYP PSO0 PSO1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6
+  Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 DFTRAMBYP RET1N DFTRAMBYP SEL_D SEL_SI SEL_TD DFTRAMBYP
+  DFTRAMBYP SO0 SO1 DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP TEN DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP TPEN DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDPE VDDPE VDDC_L VDDC_L VDDC_L VDDPE VPW VPW WENY_0 WENY_1 WENY_2
+  WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10 WENY_11 WENY_12
+  WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15 RAMSP4096X16BOTCAPROW
XIO_SLICE DUM_ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15
+  BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23
+  BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9
+  BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17
+  BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25
+  BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31 CA0 CA1 CA2 CAY0 CAY1
+  CAY2 CEN CENY CLK CRE1 CRE2 DBL RET NWCLK PEN PENSI PENSO PSO0 PSO1 TPEN
+  DUMMY_DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13
+  D_14 D_15 EMAW0 EMAW1 EMA0 EMA1 EMA2 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4
+  FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN
+  GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP LOG0_DWL TEN DUM_NACTC NACT_CC NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11
+  NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18
+  NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25
+  NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8
+  NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15
+  NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22
+  NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29
+  NBL[3]_30 NBL[3]_31 NGWE DUM_RETNVT Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9
+  Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3
+  RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RET_267
+  RET1N SAE_DUMMY SEL_D SEL_SI SEL_TD SO0 SO1 DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP DFTRAMBYP
+  DFTRAMBYP VDDC_L VDDP VDDPE VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5
+  WENY_6 WENY_7 WENY_8 WENY_9 WENY_10 WENY_11 WENY_12 WENY_13 WENY_14 WENY_15
+  WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 WEN_8 WEN_9 WEN_10 WEN_11
+  WEN_12 WEN_13 WEN_14 WEN_15 RAMSP4096X16IO_SLICE
XMEMSLICE RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] BL[0]_0
+  BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9
+  BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17
+  BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25
+  BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[2]_0 BL[2]_1 BL[2]_2
+  BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11
+  BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19
+  BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27
+  BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 DUM_ACTP DUM_RETNVT DUM_NACTC DBL DUMMY_DWL_R EMA0 EMA1
+  EMA2 GTP GTP LA_P2[0] LA_P2[1] LA_P2[2] DFTRAMBYP LOG0_DWL TEN NACT_CC
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14
+  NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21
+  NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28
+  NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NGWE RET RET_267 SAE_DUMMY VDDC_L
+  VDDP VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VPW RAMSP4096X16MEM_SLICE
.ENDS RAMSP4096X16TILE_TOP
****
.SUBCKT RAMSP4096X16 VDDCE VDDPE VSSE Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9]
+  Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN WEN[15] WEN[14]
+  WEN[13] WEN[12] WEN[11] WEN[10] WEN[9] WEN[8] WEN[7] WEN[6] WEN[5] WEN[4]
+  WEN[3] WEN[2] WEN[1] WEN[0] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3]
+  A[2] A[1] A[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5]
+  D[4] D[3] D[2] D[1] D[0] EMA[2] EMA[1] EMA[0] EMAW[1] EMAW[0] GWEN RET1N
** RAMSP4096X16: 410196 flat devices **
XI0 A[0] A[1] A[2] CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP D[0] D[1]
+  D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+  EMA[0] EMA[1] EMA[2] EMAW[0] EMAW[1] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4
+  FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY
+  A[3] A[4] A[5] LAY0 LAY1 LAY2 PEN PENSI PENSO PSO0 PSO1 Q[0] Q[1] Q[2] Q[3]
+  Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] A[6] A[7]
+  A[8] A[9] A[10] A[11] RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RET1N SO0 SO1 TEN TPEN
+  VDDCE VDDPE VSSE WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7
+  WENY_8 WENY_9 WENY_10 WENY_11 WENY_12 WENY_13 WENY_14 WENY_15 WEN[0] WEN[1]
+  WEN[2] WEN[3] WEN[4] WEN[5] WEN[6] WEN[7] WEN[8] WEN[9] WEN[10] WEN[11]
+  WEN[12] WEN[13] WEN[14] WEN[15] RAMSP4096X16TILE_TOP
.ENDS RAMSP4096X16
