* 
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Single Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.299um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 16 -b\
* Configuration: mux off -bus_notation on -check_instname on -diode\
* Configuration: s on -drive 6 -ema on -frequency 1.0 -instname RAM\
* Configuration: SP4096X16 -left_bus_delim "[" -mux 8 -mvt "" -name\
* Configuration: _case upper -power_type otc -prefix "" -pwr_gnd_re\
* Configuration: name vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention \
* Configuration: on -right_bus_delim "]" -ser none -site_def off -t\
* Configuration: op_layer m5-m10 -words 4096 -write_mask on -write_\
* Configuration: thru off -corners ff_1p10v_1p10v_0c,ff_1p10v_1p10v\
* Configuration: _125c,ff_1p10v_1p10v_m40c,ff_1p21v_1p21v_0c,ff_1p2\
* Configuration: 1v_1p21v_125c,ff_1p21v_1p21v_m40c,ff_1p26v_1p26v_0\
* Configuration: c,ff_1p26v_1p26v_125c,ff_1p26v_1p26v_85c,ff_1p26v_\
* Configuration: 1p26v_m40c,ss_0p90v_0p90v_0c,ss_0p90v_0p90v_125c,s\
* Configuration: s_0p90v_0p90v_m40c,ss_0p99v_0p99v_0c,ss_0p99v_0p99\
* Configuration: v_125c,ss_0p99v_0p99v_m40c,ss_1p08v_1p08v_0c,ss_1p\
* Configuration: 08v_1p08v_125c,ss_1p08v_1p08v_m40c,tt_1p00v_1p00v_\
* Configuration: 125c,tt_1p00v_1p00v_25c,tt_1p00v_1p00v_85c,tt_1p10\
* Configuration: v_1p10v_125c,tt_1p10v_1p10v_25c,tt_1p10v_1p10v_85c\
* Configuration: ,tt_1p20v_1p20v_125c,tt_1p20v_1p20v_25c,tt_1p20v_1\
* Configuration: p20v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RAMSP4096X16BOTCAP8 D LOG0 Q TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN
+  WENY
** RAMSP4096X16BOTCAP8: 4 flat devices **
DI77.D_Diode_X_dio VPW TWEN NDIO11LL AREA=0.035P PJ=0.78U
DI78.D_Diode_X_dio VPW TD NDIO11LL AREA=0.035P PJ=0.78U
DI80.D_Diode_X_dio VPW D NDIO11LL AREA=0.035P PJ=0.78U
DI82.D_Diode_X_dio VPW WEN NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP4096X16BOTCAP8
****
.SUBCKT RAMSP4096X16BOTCAP8_RPT D LOG0 Q VDDCE VNWP VPW WEN WENY
** RAMSP4096X16BOTCAP8_RPT: 4 flat devices **
XI0 D LOG0 Q LOG0 LOG0 VDDCE VNWP VNWP VPW VPW VPW WEN WENY
+  RAMSP4096X16BOTCAP8
.ENDS RAMSP4096X16BOTCAP8_RPT
****
.SUBCKT RAMSP4096X16MIDBOT_BIST CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2
+  EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LOG0 NWCLK PEN PENSI PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0
+  TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5
+  VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP4096X16MIDBOT_BIST: 60 flat devices **
DI100.D_Diode_X_dio VPW FCA1_3 NDIO11LL AREA=0.035P PJ=0.78U
DI102.D_Diode_X_dio VPW CRE1 NDIO11LL AREA=0.035P PJ=0.78U
DI104.D_Diode_X_dio VPW RA5 NDIO11LL AREA=0.035P PJ=0.78U
DI106.D_Diode_X_dio VPW RA3 NDIO11LL AREA=0.035P PJ=0.78U
DI107.D_Diode_X_dio VPW RA4 NDIO11LL AREA=0.035P PJ=0.78U
DI108.D_Diode_X_dio VPW LA2 NDIO11LL AREA=0.035P PJ=0.78U
DI110.D_Diode_X_dio VPW LA1 NDIO11LL AREA=0.035P PJ=0.78U
DI111.D_Diode_X_dio VPW RA2 NDIO11LL AREA=0.035P PJ=0.78U
DI112.D_Diode_X_dio VPW RA1 NDIO11LL AREA=0.035P PJ=0.78U
DI114.D_Diode_X_dio VPW LA0 NDIO11LL AREA=0.035P PJ=0.78U
DI115.D_Diode_X_dio VPW CA2 NDIO11LL AREA=0.035P PJ=0.78U
DI117.D_Diode_X_dio VPW RA0 NDIO11LL AREA=0.035P PJ=0.78U
DI118.D_Diode_X_dio VPW TPEN NDIO11LL AREA=0.035P PJ=0.78U
DI119.D_Diode_X_dio VPW PEN NDIO11LL AREA=0.035P PJ=0.78U
DI120.D_Diode_X_dio VPW TGWEN NDIO11LL AREA=0.035P PJ=0.78U
DI121.D_Diode_X_dio VPW TCEN NDIO11LL AREA=0.035P PJ=0.78U
DI122.D_Diode_X_dio VPW CA0 NDIO11LL AREA=0.035P PJ=0.78U
DI123.D_Diode_X_dio VPW PENSI NDIO11LL AREA=0.035P PJ=0.78U
DI124.D_Diode_X_dio VPW CA1 NDIO11LL AREA=0.035P PJ=0.78U
DI125.D_Diode_X_dio VPW TLA1 NDIO11LL AREA=0.035P PJ=0.78U
DI126.D_Diode_X_dio VPW TLA2 NDIO11LL AREA=0.035P PJ=0.78U
DI127.D_Diode_X_dio VPW TRA4 NDIO11LL AREA=0.035P PJ=0.78U
DI128.D_Diode_X_dio VPW TRA5 NDIO11LL AREA=0.035P PJ=0.78U
DI129.D_Diode_X_dio VPW TRA3 NDIO11LL AREA=0.035P PJ=0.78U
DI130.D_Diode_X_dio VPW TRA2 NDIO11LL AREA=0.035P PJ=0.78U
DI131.D_Diode_X_dio VPW TLA0 NDIO11LL AREA=0.035P PJ=0.78U
DI132.D_Diode_X_dio VPW TCA2 NDIO11LL AREA=0.035P PJ=0.78U
DI133.D_Diode_X_dio VPW TRA0 NDIO11LL AREA=0.035P PJ=0.78U
DI134.D_Diode_X_dio VPW TRA1 NDIO11LL AREA=0.035P PJ=0.78U
DI135.D_Diode_X_dio VPW TCA1 NDIO11LL AREA=0.035P PJ=0.78U
DI136.D_Diode_X_dio VPW TCA0 NDIO11LL AREA=0.035P PJ=0.78U
DI137.D_Diode_X_dio VPW GWEN NDIO11LL AREA=0.035P PJ=0.78U
DI138.D_Diode_X_dio VPW CEN NDIO11LL AREA=0.035P PJ=0.78U
DI139.D_Diode_X_dio VPW RDT NDIO11LL AREA=0.035P PJ=0.78U
DI140.D_Diode_X_dio VPW TEN NDIO11LL AREA=0.035P PJ=0.78U
DI142.D_Diode_X_dio VPW DFTRAMBYP NDIO11LL AREA=0.035P PJ=0.78U
DI146.D_Diode_X_dio VPW EMA2 NDIO11LL AREA=0.035P PJ=0.78U
DI147.D_Diode_X_dio VPW EMA1 NDIO11LL AREA=0.035P PJ=0.78U
DI148.D_Diode_X_dio VPW EMA0 NDIO11LL AREA=0.035P PJ=0.78U
DI151.D_Diode_X_dio VPW EMAW0 NDIO11LL AREA=0.035P PJ=0.78U
DI152.D_Diode_X_dio VPW EMAW1 NDIO11LL AREA=0.035P PJ=0.78U
DI154.D_Diode_X_dio VPW CLK NDIO11LL AREA=0.035P PJ=0.78U
DI157.D_Diode_X_dio VPW SE NDIO11LL AREA=0.035P PJ=0.78U
DI158.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
DI159.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
DI160.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
DI61.D_Diode_X_dio VPW FCA1_0 NDIO11LL AREA=0.035P PJ=0.78U
DI65.D_Diode_X_dio VPW FCA1_1 NDIO11LL AREA=0.035P PJ=0.78U
DI66.D_Diode_X_dio VPW FCA1_2 NDIO11LL AREA=0.035P PJ=0.78U
DI77.D_Diode_X_dio VPW FCA2_6 NDIO11LL AREA=0.035P PJ=0.78U
DI90.D_Diode_X_dio VPW FCA2_4 NDIO11LL AREA=0.035P PJ=0.78U
DI91.D_Diode_X_dio VPW FCA2_5 NDIO11LL AREA=0.035P PJ=0.78U
DI92.D_Diode_X_dio VPW FCA2_2 NDIO11LL AREA=0.035P PJ=0.78U
DI93.D_Diode_X_dio VPW FCA2_1 NDIO11LL AREA=0.035P PJ=0.78U
DI94.D_Diode_X_dio VPW FCA2_3 NDIO11LL AREA=0.035P PJ=0.78U
DI95.D_Diode_X_dio VPW FCA1_6 NDIO11LL AREA=0.035P PJ=0.78U
DI96.D_Diode_X_dio VPW FCA1_4 NDIO11LL AREA=0.035P PJ=0.78U
DI97.D_Diode_X_dio VPW FCA1_5 NDIO11LL AREA=0.035P PJ=0.78U
DI98.D_Diode_X_dio VPW FCA2_0 NDIO11LL AREA=0.035P PJ=0.78U
DI99.D_Diode_X_dio VPW CRE2 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP4096X16MIDBOT_BIST
****
.SUBCKT RAMSP4096X16MIDBOT_BIST_WRAPT CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK
+  CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1
+  EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1
+  LAY2 LOG0 NWCLK PEN PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2
+  TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP4096X16MIDBOT_BIST_WRAPT: 60 flat devices **
XI0 CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R
+  DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1
+  FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4
+  FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN PENSI
+  PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN
+  TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE VDDC_L VDDC_R
+  VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE RAMSP4096X16MIDBOT_BIST
.ENDS RAMSP4096X16MIDBOT_BIST_WRAPT
****
.SUBCKT RAMSP4096X16BOTCORNER LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP4096X16BOTCORNER: 2 flat devices **
DI74.D_Diode_X_dio VPW PSI NDIO11LL AREA=0.035P PJ=0.78U
DI85.D_Diode_X_dio VPW SI NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP4096X16BOTCORNER
****
.SUBCKT RAMSP4096X16BOTCORNER_WRAPT LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP4096X16BOTCORNER_WRAPT: 2 flat devices **
XI0 LOG0 PSI SI VNWC VNWP VPW VSS RAMSP4096X16BOTCORNER
.ENDS RAMSP4096X16BOTCORNER_WRAPT
****
.SUBCKT RAMSP4096X16BOTCAPROW CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMA0 EMA1 EMA2 EMAW0
+  EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2
+  FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0
+  NWCLK PEN PENSI PENSO PSI_0 PSI_1 PSO0 PSO1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SI_0 SI_1 SO0 SO1 TCA0
+  TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC_0 VNWC_1 VNWC_2 VNWP VPW VSSE WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10
+  WENY_11 WENY_12 WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMSP4096X16BOTCAPROW: 128 flat devices **
XCENTRE CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP
+  DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN
+  PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN TGWEN TLA0
+  TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE_8 VDDC_L VDDC_R VDDPE
+  VDDP_CLKGEN VNWC_1 VNWP VPW VPW VSSE RAMSP4096X16MIDBOT_BIST_WRAPT
XLEFT LOG0 PSI_0 SI_0 VNWC_0 VNWP VPW VPW RAMSP4096X16BOTCORNER_WRAPT
XLEFT_COL_0 D_0 LOG0 Q_0 VDDCE_0 VNWP VPW WEN_0 WENY_0 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_1 D_1 LOG0 Q_1 VDDCE_1 VNWP VPW WEN_1 WENY_1 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_2 D_2 LOG0 Q_2 VDDCE_2 VNWP VPW WEN_2 WENY_2 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_3 D_3 LOG0 Q_3 VDDCE_3 VNWP VPW WEN_3 WENY_3 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_4 D_4 LOG0 Q_4 VDDCE_4 VNWP VPW WEN_4 WENY_4 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_5 D_5 LOG0 Q_5 VDDCE_5 VNWP VPW WEN_5 WENY_5 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_6 D_6 LOG0 Q_6 VDDCE_6 VNWP VPW WEN_6 WENY_6 RAMSP4096X16BOTCAP8_RPT
XLEFT_COL_7 D_7 LOG0 Q_7 VDDCE_7 VNWP VPW WEN_7 WENY_7 RAMSP4096X16BOTCAP8_RPT
XRIGHT LOG0 PSI_1 SI_1 VNWC_2 VNWP VPW VPW RAMSP4096X16BOTCORNER_WRAPT
XRIGHT_COL_0 D_8 LOG0 Q_8 VDDCE_9 VNWP VPW WEN_8 WENY_8
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_1 D_9 LOG0 Q_9 VDDCE_10 VNWP VPW WEN_9 WENY_9
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_2 D_10 LOG0 Q_10 VDDCE_11 VNWP VPW WEN_10 WENY_10
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_3 D_11 LOG0 Q_11 VDDCE_12 VNWP VPW WEN_11 WENY_11
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_4 D_12 LOG0 Q_12 VDDCE_13 VNWP VPW WEN_12 WENY_12
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_5 D_13 LOG0 Q_13 VDDCE_14 VNWP VPW WEN_13 WENY_13
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_6 D_14 LOG0 Q_14 VDDCE_15 VNWP VPW WEN_14 WENY_14
+  RAMSP4096X16BOTCAP8_RPT
XRIGHT_COL_7 D_15 LOG0 Q_15 VDDCE_16 VNWP VPW WEN_15 WENY_15
+  RAMSP4096X16BOTCAP8_RPT
.ENDS RAMSP4096X16BOTCAPROW
****
.SUBCKT RAMSP4096X16COLM8_BIST_WM ADDR BL0 BL1 BL2 BL3 BL4 BL5 BL6 BL7 BLPRECH
+  D DFTRAMBYP DWL IADDR IADDR_NSAE LOG0 NACT_CC NADDR NADDR_NSAE NBL0 NBL1
+  NBL2 NBL3 NBL4 NBL5 NBL6 NBL7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAE
+  SAO SAPRECH SEL_D SEL_SI SEL_TD SI SO TD TE TWEN TWENL TWENR TWEN_PRG VDDC
+  VDDCE VDDPE VNWC VNWP VPW VSS VSSE WEN WENL WENR WENY WEN_PRG YW0 YW1 YW2
+  YW3
** RAMSP4096X16COLM8_BIST_WM: 239 flat devices **
X_M_cd.I39.MXNA1 _CD.NBLPRECH BLPRECH VSS VPW N11LL_CKT W=0.79U L=0.04U
X_M_cd.I39.MXPA1 _CD.NBLPRECH BLPRECH VDDPE VNWP P11LL_CKT W=1.725U L=0.04U
X_M_cd.I46.MXNA1 SAE NSAE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_cd.I46.MXPA1 SAE NSAE VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_cd.I56.MXNA1 _CD.NSAPRECH SAPRECH _CD.I56.N1 VPW N11LL_CKT W=0.25U L=0.04U
X_M_cd.I56.MXNA2 _CD.I56.N1 NSAE VSS VPW N11LL_CKT W=0.25U L=0.04U
X_M_cd.I56.MXPA1 _CD.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_cd.I56.MXPA2 _CD.NSAPRECH NSAE VDDPE VNWP P11LL_CKT W=0.33U L=0.04U
X_M_cd.MXN18 _CD.SAINT LOG0 VSS VPW N11LL_CKT W=1.175U L=0.04U
X_M_cd.MXP0 _CD.NSD IADDR_NSAE _CD.NSD0 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP1 _CD.SD IADDR_NSAE _CD.SD0 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP2 _CD.SD NADDR_NSAE _CD.SD1 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP3 _CD.NSD NADDR_NSAE _CD.NSD1 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP5 _CD.SD1 _CD.NSAPRECH VDDPE VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP6 _CD.NSD1 _CD.NSAPRECH VDDPE VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP7 _CD.NSD0 _CD.NSAPRECH VDDPE VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd.MXP8 _CD.SD0 _CD.NSAPRECH VDDPE VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd._dwl_load_0.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._dwl_load_1.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._dwl_load_2.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._dwl_load_3.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._rw0_1._mx0.MXN0 NBL0 YW0 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw0_1._mx0.MXN1 BL0 YW0 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw0_1._mx0.MXP1 NBL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx0.MXP10 _CD._RW0_1._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw0_1._mx0.MXP3 _CD.NSD0 NYR0 NBL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw0_1._mx0.MXP4 _CD.SD0 NYR0 BL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw0_1._mx0.MXP5 NBL0 BL0 _CD._RW0_1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw0_1._mx0.MXP7 BL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx0.MXP8 NBL0 _CD.NBLPRECH BL0 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx0.MXP9 BL0 NBL0 _CD._RW0_1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw0_1._mx1.MXN0 NBL1 YW1 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw0_1._mx1.MXN1 BL1 YW1 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw0_1._mx1.MXP1 NBL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx1.MXP10 _CD._RW0_1._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw0_1._mx1.MXP3 _CD.NSD0 NYR1 NBL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw0_1._mx1.MXP4 _CD.SD0 NYR1 BL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw0_1._mx1.MXP5 NBL1 BL1 _CD._RW0_1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw0_1._mx1.MXP7 BL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx1.MXP8 NBL1 _CD.NBLPRECH BL1 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw0_1._mx1.MXP9 BL1 NBL1 _CD._RW0_1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw2_3._mx0.MXN0 NBL2 YW2 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw2_3._mx0.MXN1 BL2 YW2 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw2_3._mx0.MXP1 NBL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx0.MXP10 _CD._RW2_3._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw2_3._mx0.MXP3 _CD.NSD0 NYR2 NBL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw2_3._mx0.MXP4 _CD.SD0 NYR2 BL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw2_3._mx0.MXP5 NBL2 BL2 _CD._RW2_3._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw2_3._mx0.MXP7 BL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx0.MXP8 NBL2 _CD.NBLPRECH BL2 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx0.MXP9 BL2 NBL2 _CD._RW2_3._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw2_3._mx1.MXN0 NBL3 YW3 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw2_3._mx1.MXN1 BL3 YW3 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw2_3._mx1.MXP1 NBL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx1.MXP10 _CD._RW2_3._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw2_3._mx1.MXP3 _CD.NSD0 NYR3 NBL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw2_3._mx1.MXP4 _CD.SD0 NYR3 BL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw2_3._mx1.MXP5 NBL3 BL3 _CD._RW2_3._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw2_3._mx1.MXP7 BL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx1.MXP8 NBL3 _CD.NBLPRECH BL3 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw2_3._mx1.MXP9 BL3 NBL3 _CD._RW2_3._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw4_5._mx0.MXN0 NBL4 YW0 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw4_5._mx0.MXN1 BL4 YW0 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw4_5._mx0.MXP1 NBL4 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx0.MXP10 _CD._RW4_5._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw4_5._mx0.MXP3 _CD.NSD1 NYR0 NBL4 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw4_5._mx0.MXP4 _CD.SD1 NYR0 BL4 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw4_5._mx0.MXP5 NBL4 BL4 _CD._RW4_5._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw4_5._mx0.MXP7 BL4 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx0.MXP8 NBL4 _CD.NBLPRECH BL4 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx0.MXP9 BL4 NBL4 _CD._RW4_5._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw4_5._mx1.MXN0 NBL5 YW1 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw4_5._mx1.MXN1 BL5 YW1 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw4_5._mx1.MXP1 NBL5 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx1.MXP10 _CD._RW4_5._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw4_5._mx1.MXP3 _CD.NSD1 NYR1 NBL5 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw4_5._mx1.MXP4 _CD.SD1 NYR1 BL5 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw4_5._mx1.MXP5 NBL5 BL5 _CD._RW4_5._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw4_5._mx1.MXP7 BL5 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx1.MXP8 NBL5 _CD.NBLPRECH BL5 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw4_5._mx1.MXP9 BL5 NBL5 _CD._RW4_5._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw6_7._mx0.MXN0 NBL6 YW2 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw6_7._mx0.MXN1 BL6 YW2 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw6_7._mx0.MXP1 NBL6 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx0.MXP10 _CD._RW6_7._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw6_7._mx0.MXP3 _CD.NSD1 NYR2 NBL6 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw6_7._mx0.MXP4 _CD.SD1 NYR2 BL6 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw6_7._mx0.MXP5 NBL6 BL6 _CD._RW6_7._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw6_7._mx0.MXP7 BL6 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx0.MXP8 NBL6 _CD.NBLPRECH BL6 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx0.MXP9 BL6 NBL6 _CD._RW6_7._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw6_7._mx1.MXN0 NBL7 YW3 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw6_7._mx1.MXN1 BL7 YW3 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._rw6_7._mx1.MXP1 NBL7 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx1.MXP10 _CD._RW6_7._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._rw6_7._mx1.MXP3 _CD.NSD1 NYR3 NBL7 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw6_7._mx1.MXP4 _CD.SD1 NYR3 BL7 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._rw6_7._mx1.MXP5 NBL7 BL7 _CD._RW6_7._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._rw6_7._mx1.MXP7 BL7 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx1.MXP8 NBL7 _CD.NBLPRECH BL7 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._rw6_7._mx1.MXP9 BL7 NBL7 _CD._RW6_7._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._sa1.MXN17 _CD.NSD _CD.SD _CD.SAINT VPW N11LL_CKT W=2.36U L=0.085U
X_M_cd._sa1.MXN18 _CD.SAINT SAE VSS VPW N11LL_CKT W=1.175U L=0.04U
X_M_cd._sa1.MXN19 _CD.SD _CD.NSD _CD.SAINT VPW N11LL_CKT W=2.36U L=0.085U
X_M_cd._sa1.MXP24 _CD.NSD _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP25 _CD.NSD _CD.NSAPRECH _CD.SD VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP26 _CD.SD _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP27 _CD.NSD _CD.SD VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXP28 _CD.SD _CD.NSD VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._salat1.I62.MXNA1 SAO _CD._SALAT1.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat1.I62.MXPA1 SAO _CD._SALAT1.SD_LAT VDDPE VNWP P11LL_CKT W=0.63U
+  L=0.04U
X_M_cd._salat1.I68.MXNA1 _CD._SALAT1.WCLK_WT NWCLK_WT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.I68.MXPA1 _CD._SALAT1.WCLK_WT NWCLK_WT VDDPE VNWP P11LL_CKT
+  W=0.21U L=0.04U
X_M_cd._salat1.I69.MXNA1 _CD._SALAT1.I69.N1 D_WT VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._salat1.I69.MXNOE _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I69.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I69.MXPA1 _CD._SALAT1.I69.P1 D_WT VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.I69.MXPOEN _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I69.P1 VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXNA1 _CD._SALAT1.I70.N1 _CD._SALAT1.SD_LAT VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXNOE _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I70.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXPA1 _CD._SALAT1.I70.P1 _CD._SALAT1.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXPOEN _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I70.P1 VNWP P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I82.MXNA1 _CD._SALAT1.NLAT_E SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat1.I82.MXPA1 _CD._SALAT1.NLAT_E SAE VDDPE VNWP P11LL_CKT W=0.25U
+  L=0.04U
X_M_cd._salat1.MXN8 _CD._SALAT1.N1B _CD._SALAT1.NSD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.MXN9 _CD._SALAT1.SD_LAT _CD._SALAT1.NLAT_E _CD._SALAT1.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat1.MXP6 _CD._SALAT1.SD_LAT SAE _CD._SALAT1.P1B VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXP7 _CD._SALAT1.P1B _CD._SALAT1.NSD_LAT VDDPE VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXPs _CD._SALAT1.SD_LAT _CD.NSD _CD._SALAT1.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat1.MX_ndmy _CD._SALAT1.NSD_DUM _CD.SD _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.MX_nlat _CD._SALAT1.N1A SAE VSS VPW N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.MX_pdmy _CD._SALAT1.NSD_DUM _CD.SD _CD._SALAT1.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_pnsae _CD._SALAT1.P1A _CD._SALAT1.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_sd_n _CD._SALAT1.SD_LAT _CD.NSD _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_wr.I0.MXNA1 _WR.NE1 IADDR _WR.I0.N1 VPW N11LL_CKT W=0.42U L=0.04U
X_M_wr.I0.MXNA2 _WR.I0.N1 _WR.NWEN VSS VPW N11LL_CKT W=0.42U L=0.04U
X_M_wr.I0.MXPA1 _WR.NE1 IADDR VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I0.MXPA2 _WR.NE1 _WR.NWEN VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I115.MXNA1 _WR.NE0 NADDR _WR.I115.N1 VPW N11LL_CKT W=0.42U L=0.04U
X_M_wr.I115.MXNA2 _WR.I115.N1 _WR.NWEN VSS VPW N11LL_CKT W=0.42U L=0.04U
X_M_wr.I115.MXPA1 _WR.NE0 NADDR VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I115.MXPA2 _WR.NE0 _WR.NWEN VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I173.MXNA1 _WR.ND_LAT _WR.D_LAT VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr.I173.MXPA1 _WR.ND_LAT _WR.D_LAT VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I176.MXNA1 SO SAO VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_wr.I176.MXPA1 SO SAO VDDPE VNWP P11LL_CKT W=0.145U L=0.04U
X_M_wr.I178.I169.MXNA1 _WR.I178.NWRONE _WR.NE1 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I178.I169.MXNA2 _WR.I178.NWRONE _WR.D_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I178.I169.MXPA1 _WR.I178.NWRONE _WR.NE1 _WR.I178.I169.P1 VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I178.I169.MXPA2 _WR.I178.I169.P1 _WR.D_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I178.I179.MXNA1 _WR.I178.NWRZERO _WR.NE1 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I178.I179.MXNA2 _WR.I178.NWRZERO _WR.ND_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I178.I179.MXPA1 _WR.I178.NWRZERO _WR.NE1 _WR.I178.I179.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr.I178.I179.MXPA2 _WR.I178.I179.P1 _WR.ND_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I178.MXN0 WRONE1 _WR.I178.NWRONE VSS VPW N11LL_CKT W=1.95U L=0.04U
X_M_wr.I178.MXN1 WRZERO1 _WR.I178.NWRZERO VSS VPW N11LL_CKT W=1.95U L=0.04U
X_M_wr.I178.MXP0 _WR.I178.HZWRONE _WR.NE1 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I178.MXP1 WRONE1 _WR.I178.NWRONE _WR.I178.HZWRONE VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_wr.I178.MXP11 _WR.I178.HZWRONE _WR.WCLK VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I178.MXP12 _WR.I178.HZWRZERO _WR.WCLK VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I178.MXP2 WRZERO1 _WR.I178.NWRZERO _WR.I178.HZWRZERO VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_wr.I178.MXP3 _WR.I178.HZWRZERO _WR.NE1 VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I179.I169.MXNA1 _WR.I179.NWRONE _WR.NE0 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I179.I169.MXNA2 _WR.I179.NWRONE _WR.D_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I179.I169.MXPA1 _WR.I179.NWRONE _WR.NE0 _WR.I179.I169.P1 VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I179.I169.MXPA2 _WR.I179.I169.P1 _WR.D_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I179.I179.MXNA1 _WR.I179.NWRZERO _WR.NE0 VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I179.I179.MXNA2 _WR.I179.NWRZERO _WR.ND_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr.I179.I179.MXPA1 _WR.I179.NWRZERO _WR.NE0 _WR.I179.I179.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr.I179.I179.MXPA2 _WR.I179.I179.P1 _WR.ND_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr.I179.MXN0 WRONE0 _WR.I179.NWRONE VSS VPW N11LL_CKT W=1.95U L=0.04U
X_M_wr.I179.MXN1 WRZERO0 _WR.I179.NWRZERO VSS VPW N11LL_CKT W=1.95U L=0.04U
X_M_wr.I179.MXP0 _WR.I179.HZWRONE _WR.NE0 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I179.MXP1 WRONE0 _WR.I179.NWRONE _WR.I179.HZWRONE VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_wr.I179.MXP11 _WR.I179.HZWRONE _WR.WCLK VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I179.MXP12 _WR.I179.HZWRZERO _WR.WCLK VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I179.MXP2 WRZERO0 _WR.I179.NWRZERO _WR.I179.HZWRZERO VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_wr.I179.MXP3 _WR.I179.HZWRZERO _WR.NE0 VDDPE VNWP P11LL_CKT W=0.56U
+  L=0.04U
X_M_wr.I180.MXNA1 NADDR ADDR VSS VPW N11LL_CKT W=0.365U L=0.04U
X_M_wr.I180.MXPA1 NADDR ADDR VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I181.MXNA1 IADDR NADDR VSS VPW N11LL_CKT W=0.365U L=0.04U
X_M_wr.I181.MXPA1 IADDR NADDR VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I182.MXNA1 _WR.NWEN _WR.WEN_LAT VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_wr.I182.MXPA1 _WR.NWEN _WR.WEN_LAT VDDPE VNWP P11LL_CKT W=0.21U L=0.04U
X_M_wr.I205.MXNA1 D_WT _WR.ND_LAT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I205.MXPA1 D_WT _WR.ND_LAT VDDPE VNWP P11LL_CKT W=0.25U L=0.04U
X_M_wr.IV_WrClk.MXNA1 _WR.WCLK NWCLK VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_wr.IV_WrClk.MXPA1 _WR.WCLK NWCLK VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_M_wr._dlat.I1_0.MXNA1 _WR._DLAT.NSEL3 SEL_SI VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_0.MXPA1 _WR._DLAT.NSEL3 SEL_SI VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_1.MXNA1 _WR._DLAT.NSEL2 SEL_TD VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_1.MXPA1 _WR._DLAT.NSEL2 SEL_TD VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_2.MXNA1 _WR._DLAT.NSEL1 SEL_D VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_2.MXPA1 _WR._DLAT.NSEL1 SEL_D VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I50.MXNA1 _WR.D_LAT _WR.DLAT_NQ VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.I50.MXPA1 _WR.D_LAT _WR.DLAT_NQ VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat.I55.MXNA1 _WR._DLAT.I55.N1 _WR.D_LAT VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I55.MXNOE _WR.DLAT_NQ _WR.WCLK _WR._DLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat.I55.MXPA1 _WR._DLAT.I55.P1 _WR.D_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I55.MXPOEN _WR.DLAT_NQ NWCLK _WR._DLAT.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat.I65.MXNOE _WR.DLAT_NQ NWCLK _WR._DLAT.ND VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.I65.MXPOEN _WR.DLAT_NQ _WR.WCLK _WR._DLAT.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXN1 _WR._DLAT.N2 TD VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN2 _WR._DLAT.N1 D VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN3 _WR._DLAT.ND SEL_D _WR._DLAT.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXN4 _WR._DLAT.ND SEL_TD _WR._DLAT.N2 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXN5 _WR._DLAT.N3 SI VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN6 _WR._DLAT.ND SEL_SI _WR._DLAT.N3 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXP0 _WR._DLAT.ND _WR._DLAT.NSEL1 _WR._DLAT.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP1 _WR._DLAT.P1 D VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat.MXP2 _WR._DLAT.ND _WR._DLAT.NSEL2 _WR._DLAT.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP3 _WR._DLAT.P2 TD VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat.MXP4 _WR._DLAT.ND _WR._DLAT.NSEL3 _WR._DLAT.P3 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP5 _WR._DLAT.P3 SI VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._wenmux0.I0.MXNA1 _WR._WENMUX0.NDY _WR._WENMUX0.IDY _WR._WENMUX0.I0.N1
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXNA2 _WR._WENMUX0.I0.N1 DFTRAMBYP VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXPA1 _WR._WENMUX0.NDY _WR._WENMUX0.IDY VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXPA2 _WR._WENMUX0.NDY DFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenmux0.I50.MXNA1 _WR.WEN_LAT _WR.WE_LAT VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._wenmux0.I50.MXPA1 _WR.WEN_LAT _WR.WE_LAT VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._wenmux0.I55.MXNA1 _WR._WENMUX0.I55.N1 _WR.WEN_LAT VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXNOE _WR.WE_LAT _WR.WCLK _WR._WENMUX0.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXPA1 _WR._WENMUX0.I55.P1 _WR.WEN_LAT VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXPOEN _WR.WE_LAT NWCLK _WR._WENMUX0.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I57.MXNA1 _WR._WENMUX0.NSEL TE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._wenmux0.I57.MXPA1 _WR._WENMUX0.NSEL TE VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_wr._wenmux0.I62.MXNA1 WENY _WR._WENMUX0.NDY VSS VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_wr._wenmux0.I62.MXPA1 WENY _WR._WENMUX0.NDY VDDPE VNWP P11LL_CKT W=1.12U
+  L=0.04U
X_M_wr._wenmux0.I63.MXNA1 _WR._WENMUX0.IDY _WR._WENMUX0.ND VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I63.MXPA1 _WR._WENMUX0.IDY _WR._WENMUX0.ND VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenmux0.I65.MXNOE _WR.WE_LAT NWCLK _WR._WENMUX0.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.I65.MXPOEN _WR.WE_LAT _WR.WCLK _WR._WENMUX0.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXN1 _WR._WENMUX0.ND TWEN_PRG _WR._WENMUX0.N2 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN2 _WR._WENMUX0.ND WEN_PRG _WR._WENMUX0.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN5 _WR._WENMUX0.N1 _WR._WENMUX0.NSEL VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN6 _WR._WENMUX0.N2 TE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._wenmux0.MXP1 _WR._WENMUX0.ND WEN_PRG _WR._WENMUX0.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXP3 _WR._WENMUX0.ND TWEN_PRG _WR._WENMUX0.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXP4 _WR._WENMUX0.P1 TE VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._wenmux0.MXP5 _WR._WENMUX0.P2 _WR._WENMUX0.NSEL VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
.ENDS RAMSP4096X16COLM8_BIST_WM
****
.SUBCKT RAMSP4096X16IOCDM_L ADDR BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL2_0 BL2_1 BL2_2
+  BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7 BL5_0 BL5_1 BL5_2
+  BL5_3 BL5_4 BL5_5 BL5_6 BL5_7 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6
+  BL6_7 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7 BLPRECH DFTRAMBYP DWL
+  D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4
+  IADDR_5 IADDR_6 IADDR_7 IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3
+  IADDR_NSAE_4 IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 LOG0 NACT_CC NADDR_0
+  NADDR_1 NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0
+  NADDR_NSAE_1 NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5
+  NADDR_NSAE_6 NADDR_NSAE_7 NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL0_4 NBL0_5 NBL0_6
+  NBL0_7 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4 NBL1_5 NBL1_6 NBL1_7 NBL2_0
+  NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6 NBL2_7 NBL3_0 NBL3_1 NBL3_2
+  NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7 NBL4_0 NBL4_1 NBL4_2 NBL4_3 NBL4_4
+  NBL4_5 NBL4_6 NBL4_7 NBL5_0 NBL5_1 NBL5_2 NBL5_3 NBL5_4 NBL5_5 NBL5_6
+  NBL5_7 NBL6_0 NBL6_1 NBL6_2 NBL6_3 NBL6_4 NBL6_5 NBL6_6 NBL6_7 NBL7_0
+  NBL7_1 NBL7_2 NBL7_3 NBL7_4 NBL7_5 NBL7_6 NBL7_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1
+  SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD SI SO TD_0
+  TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2
+  TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4
+  VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6
+  VNWC_7 VPW WENL WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
** RAMSP4096X16IOCDM_L: 1912 flat devices **
XL_IO_I1 ADDR BL0_1 BL1_1 BL2_1 BL3_1 BL4_1 BL5_1 BL6_1 BL7_1 BLPRECH D_1
+  DFTRAMBYP DWL IADDR_1 IADDR_NSAE_1 LOG0 NACT_CC NADDR_1 NADDR_NSAE_1 NBL0_1
+  NBL1_1 NBL2_1 NBL3_1 NBL4_1 NBL5_1 NBL6_1 NBL7_1 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_1 SAO_1 SAPRECH SEL_D SEL_SI SEL_TD SO_18 SO_24 TD_1 TE
+  TWEN_1 TWENR_20 TWENR_26 TWEN_1 VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW
+  WEN_1 WENR_22 WENR_28 WENY_1 WEN_1 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XL_IO_I2 ADDR BL0_2 BL1_2 BL2_2 BL3_2 BL4_2 BL5_2 BL6_2 BL7_2 BLPRECH D_2
+  DFTRAMBYP DWL IADDR_2 IADDR_NSAE_2 LOG0 NACT_CC NADDR_2 NADDR_NSAE_2 NBL0_2
+  NBL1_2 NBL2_2 NBL3_2 NBL4_2 NBL5_2 NBL6_2 NBL7_2 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_2 SAO_2 SAPRECH SEL_D SEL_SI SEL_TD SO_24 SO_30 TD_2 TE
+  TWEN_2 TWENR_26 TWENR_32 TWEN_2 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW
+  WEN_2 WENR_28 WENR_34 WENY_2 WEN_2 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XL_IO_I3 ADDR BL0_3 BL1_3 BL2_3 BL3_3 BL4_3 BL5_3 BL6_3 BL7_3 BLPRECH D_3
+  DFTRAMBYP DWL IADDR_3 IADDR_NSAE_3 LOG0 NACT_CC NADDR_3 NADDR_NSAE_3 NBL0_3
+  NBL1_3 NBL2_3 NBL3_3 NBL4_3 NBL5_3 NBL6_3 NBL7_3 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_3 SAO_3 SAPRECH SEL_D SEL_SI SEL_TD SO_30 SO_36 TD_3 TE
+  TWEN_3 TWENR_32 TWENR_38 TWEN_3 VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW
+  WEN_3 WENR_34 WENR_40 WENY_3 WEN_3 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XL_IO_I4 ADDR BL0_4 BL1_4 BL2_4 BL3_4 BL4_4 BL5_4 BL6_4 BL7_4 BLPRECH D_4
+  DFTRAMBYP DWL IADDR_4 IADDR_NSAE_4 LOG0 NACT_CC NADDR_4 NADDR_NSAE_4 NBL0_4
+  NBL1_4 NBL2_4 NBL3_4 NBL4_4 NBL5_4 NBL6_4 NBL7_4 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_4 SAO_4 SAPRECH SEL_D SEL_SI SEL_TD SO_36 SI_6 TD_4 TE
+  TWEN_4 TWENR_38 TWENL_8 TWEN_4 VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW
+  WEN_4 WENR_40 WENL_10 WENY_4 WEN_4 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XL_IO_I5 ADDR BL0_5 BL1_5 BL2_5 BL3_5 BL4_5 BL5_5 BL6_5 BL7_5 BLPRECH D_5
+  DFTRAMBYP DWL IADDR_5 IADDR_NSAE_5 LOG0 NACT_CC NADDR_5 NADDR_NSAE_5 NBL0_5
+  NBL1_5 NBL2_5 NBL3_5 NBL4_5 NBL5_5 NBL6_5 NBL7_5 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_5 SAO_5 SAPRECH SEL_D SEL_SI SEL_TD SI_6 SO_0 TD_5 TE
+  TWEN_5 TWENL_8 TWENR_2 TWEN_5 VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW
+  WEN_5 WENL_10 WENR_4 WENY_5 WEN_5 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
XL_IO_I6 ADDR BL0_6 BL1_6 BL2_6 BL3_6 BL4_6 BL5_6 BL6_6 BL7_6 BLPRECH D_6
+  DFTRAMBYP DWL IADDR_6 IADDR_NSAE_6 LOG0 NACT_CC NADDR_6 NADDR_NSAE_6 NBL0_6
+  NBL1_6 NBL2_6 NBL3_6 NBL4_6 NBL5_6 NBL6_6 NBL7_6 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_6 SAO_6 SAPRECH SEL_D SEL_SI SEL_TD SO_0 SO_12 TD_6 TE
+  TWEN_6 TWENR_2 TWENR_14 TWEN_6 VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW
+  WEN_6 WENR_4 WENR_16 WENY_6 WEN_6 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
XL_IO_L ADDR BL0_0 BL1_0 BL2_0 BL3_0 BL4_0 BL5_0 BL6_0 BL7_0 BLPRECH D_0
+  DFTRAMBYP DWL IADDR_0 IADDR_NSAE_0 LOG0 NACT_CC NADDR_0 NADDR_NSAE_0 NBL0_0
+  NBL1_0 NBL2_0 NBL3_0 NBL4_0 NBL5_0 NBL6_0 NBL7_0 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_0 SAO_0 SAPRECH SEL_D SEL_SI SEL_TD SI SO_18 TD_0 TE
+  TWEN_0 TWENL TWENR_20 TWEN_0 VDDC_0 VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW
+  WEN_0 WENL WENR_22 WENY_0 WEN_0 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
XL_IO_R ADDR BL0_7 BL1_7 BL2_7 BL3_7 BL4_7 BL5_7 BL6_7 BL7_7 BLPRECH D_7
+  DFTRAMBYP DWL IADDR_7 IADDR_NSAE_7 LOG0 NACT_CC NADDR_7 NADDR_NSAE_7 NBL0_7
+  NBL1_7 NBL2_7 NBL3_7 NBL4_7 NBL5_7 NBL6_7 NBL7_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_7 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD SO_12 SO TD_7 TE
+  TWEN_7 TWENR_14 TWENR TWEN_7 VDDC_7 VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW
+  WEN_7 WENR_16 WENR WENY_7 WEN_7 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
.ENDS RAMSP4096X16IOCDM_L
****
.SUBCKT RAMSP4096X16CCHD4_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP4096X16CCHD4_CORNER: 3 flat devices **
X_MXN0 VSSE NET17 NET16 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET21 NET20 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET25 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4_CORNER
****
.SUBCKT RAMSP4096X16IOEDGE ADDR BLPRECH DFTRAMBYP DWL LOG0 NACT_CC NSAE NWCLK
+  NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD SI TE TWEN VDDC
+  VDDCE VDDPE VNWC VPW VSS WEN YW0 YW1 YW2 YW3
** RAMSP4096X16IOEDGE: 3 flat devices **
XIO_CORNER VDDC VNWC VDDPE VPW VPW RAMSP4096X16CCHD4_CORNER
.ENDS RAMSP4096X16IOEDGE
****
.SUBCKT RAMSP4096X16RDM8 D DWL_L DWL_R IADDR IADDR_NSAE NADDR NADDR_NSAE Q SAE
+  SAO TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN WENY
** RAMSP4096X16RDM8: 12 flat devices **
X_MI0.MXNA1 IADDR_NSAE NADDR I0.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_MI0.MXNA2 I0.N1 INSAE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI0.MXPA1 IADDR_NSAE NADDR VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI0.MXPA2 IADDR_NSAE INSAE VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI149.MXNA1 Q SAO VSS VPW N11LL_CKT W=2U L=0.04U
X_MI149.MXPA1 Q SAO VDDPE VNWP P11LL_CKT W=4.12U L=0.04U
X_MI54.MXNA1 INSAE SAE VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI54.MXPA1 INSAE SAE VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI81.MXNA1 NADDR_NSAE IADDR I81.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_MI81.MXNA2 I81.N1 INSAE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI81.MXPA1 NADDR_NSAE IADDR VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI81.MXPA2 NADDR_NSAE INSAE VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
.ENDS RAMSP4096X16RDM8
****
.SUBCKT RAMSP4096X16IO_RDM_L DWL_L DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7
+  IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7
+  IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4
+  IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 NADDR_0 NADDR_1 NADDR_2 NADDR_3
+  NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1 NADDR_NSAE_2
+  NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5 NADDR_NSAE_6 NADDR_NSAE_7 Q_0 Q_1
+  Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7
+  SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0 VNWP_1
+  VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3
+  WEN_4 WEN_5 WEN_6 WEN_7
** RAMSP4096X16IO_RDM_L: 96 flat devices **
XL_RDM_1 D_1 DWL_L_2 DWL_L_0 IADDR_1 IADDR_NSAE_1 NADDR_1 NADDR_NSAE_1 Q_1
+  SAE_1 SAO_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1 VNWP_1 VPW_1 VSS_1 VSS_1 WEN_1
+  WENY_1 RAMSP4096X16RDM8
XL_RDM_2 D_2 DWL_L_6 DWL_L_2 IADDR_2 IADDR_NSAE_2 NADDR_2 NADDR_NSAE_2 Q_2
+  SAE_2 SAO_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2 VNWP_2 VPW_2 VSS_2 VSS_2 WEN_2
+  WENY_2 RAMSP4096X16RDM8
XL_RDM_3 D_3 DWL_L_8 DWL_L_6 IADDR_3 IADDR_NSAE_3 NADDR_3 NADDR_NSAE_3 Q_3
+  SAE_3 SAO_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3 VSS_3 VSS_3 WEN_3
+  WENY_3 RAMSP4096X16RDM8
XL_RDM_4 D_4 DWL_L_10 DWL_L_8 IADDR_4 IADDR_NSAE_4 NADDR_4 NADDR_NSAE_4 Q_4
+  SAE_4 SAO_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4 VNWP_4 VPW_4 VSS_4 VSS_4 WEN_4
+  WENY_4 RAMSP4096X16RDM8
XL_RDM_5 D_5 DWL_L_12 DWL_L_10 IADDR_5 IADDR_NSAE_5 NADDR_5 NADDR_NSAE_5 Q_5
+  SAE_5 SAO_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5 VNWP_5 VPW_5 VSS_5 VSS_5 WEN_5
+  WENY_5 RAMSP4096X16RDM8
XL_RDM_6 D_6 DWL_R_4 DWL_L_12 IADDR_6 IADDR_NSAE_6 NADDR_6 NADDR_NSAE_6 Q_6
+  SAE_6 SAO_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6 VNWP_6 VPW_6 VSS_6 VSS_6 WEN_6
+  WENY_6 RAMSP4096X16RDM8
XL_RDM_L D_0 DWL_L_0 DWL_R IADDR_0 IADDR_NSAE_0 NADDR_0 NADDR_NSAE_0 Q_0 SAE_0
+  SAO_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0 VSS_0 VSS_0 WEN_0 WENY_0
+  RAMSP4096X16RDM8
XL_RDM_R D_7 DWL_L DWL_R_4 IADDR_7 IADDR_NSAE_7 NADDR_7 NADDR_NSAE_7 Q_7 SAE_7
+  SAO_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7 VNWP_7 VPW_7 VSS_7 VSS_7 WEN_7 WENY_7
+  RAMSP4096X16RDM8
.ENDS RAMSP4096X16IO_RDM_L
****
.SUBCKT RAMSP4096X16CCHD4_TOPBOT BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** RAMSP4096X16CCHD4_TOPBOT: 32 flat devices **
X_MXN16 VSSE NET150 NET93 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN17 NBL[2] VPW NET97 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN18 NET88 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN19 VPW VPW NET45 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN20 NET80 NET154 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN21 VPW NET146 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN22 VPW NET114 NET61 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN23 VPW NET158 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN24 NET84 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN25 VPW NET142 NET57 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN26 VPW NET138 NET49 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN27 NET64 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN28 VPW NET130 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN29 VPW NET126 NET37 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN30 VPW NET134 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN31 NET32 NET118 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN32 VPW VPW NET41 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN33 NET104 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN34 NBL[0] VPW NET101 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN35 VSSE NET122 NET73 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET149 NET150 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 VDDC NET154 NET151 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 VNWC NET158 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 NET113 NET114 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET141 NET142 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 VNWC NET146 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP20 VNWC NET134 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP21 NET137 NET138 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP22 NET125 NET126 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP23 VNWC NET130 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP24 VDDC NET118 NET115 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP25 NET121 NET122 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMSP4096X16CCHD4_TOPBOT
****
.SUBCKT RAMSP4096X16IOTOPCAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW
** RAMSP4096X16IOTOPCAP_L: 512 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
.ENDS RAMSP4096X16IOTOPCAP_L
****
.SUBCKT RAMSP4096X16IO_ROW_L ADDR BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3
+  BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12
+  BL[0]_13 BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14
+  BL[2]_15 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  DFTRAMBYP DWL DWL_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0_0 LOG0_1 NACT_CC
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14
+  NBL[0]_15 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SO TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6
+  TWEN_7 VDDCE VDDPE VPW WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5
+  WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2
+  YW3
** RAMSP4096X16IO_ROW_L: 2523 flat devices **
XIO_CDM_ROW_L ADDR BL[0]_1 BL[0]_3 BL[0]_5 BL[0]_7 BL[0]_9 BL[0]_11 BL[0]_13
+  BL[0]_15 BL[1]_1 BL[1]_3 BL[1]_5 BL[1]_7 BL[1]_9 BL[1]_11 BL[1]_13 BL[1]_15
+  BL[2]_1 BL[2]_3 BL[2]_5 BL[2]_7 BL[2]_9 BL[2]_11 BL[2]_13 BL[2]_15 BL[3]_1
+  BL[3]_3 BL[3]_5 BL[3]_7 BL[3]_9 BL[3]_11 BL[3]_13 BL[3]_15 BL[0]_0 BL[0]_2
+  BL[0]_4 BL[0]_6 BL[0]_8 BL[0]_10 BL[0]_12 BL[0]_14 BL[1]_0 BL[1]_2 BL[1]_4
+  BL[1]_6 BL[1]_8 BL[1]_10 BL[1]_12 BL[1]_14 BL[2]_0 BL[2]_2 BL[2]_4 BL[2]_6
+  BL[2]_8 BL[2]_10 BL[2]_12 BL[2]_14 BL[3]_0 BL[3]_2 BL[3]_4 BL[3]_6 BL[3]_8
+  BL[3]_10 BL[3]_12 BL[3]_14 BLPRECH DFTRAMBYP DWL D_0 D_1 D_2 D_3 D_4 D_5
+  D_6 D_7 IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7
+  IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4
+  IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 LOG0_1 NACT_CC NADDR_0 NADDR_1
+  NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1
+  NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5 NADDR_NSAE_6
+  NADDR_NSAE_7 NBL[0]_1 NBL[0]_3 NBL[0]_5 NBL[0]_7 NBL[0]_9 NBL[0]_11
+  NBL[0]_13 NBL[0]_15 NBL[1]_1 NBL[1]_3 NBL[1]_5 NBL[1]_7 NBL[1]_9 NBL[1]_11
+  NBL[1]_13 NBL[1]_15 NBL[2]_1 NBL[2]_3 NBL[2]_5 NBL[2]_7 NBL[2]_9 NBL[2]_11
+  NBL[2]_13 NBL[2]_15 NBL[3]_1 NBL[3]_3 NBL[3]_5 NBL[3]_7 NBL[3]_9 NBL[3]_11
+  NBL[3]_13 NBL[3]_15 NBL[0]_0 NBL[0]_2 NBL[0]_4 NBL[0]_6 NBL[0]_8 NBL[0]_10
+  NBL[0]_12 NBL[0]_14 NBL[1]_0 NBL[1]_2 NBL[1]_4 NBL[1]_6 NBL[1]_8 NBL[1]_10
+  NBL[1]_12 NBL[1]_14 NBL[2]_0 NBL[2]_2 NBL[2]_4 NBL[2]_6 NBL[2]_8 NBL[2]_10
+  NBL[2]_12 NBL[2]_14 NBL[3]_0 NBL[3]_2 NBL[3]_4 NBL[3]_6 NBL[3]_8 NBL[3]_10
+  NBL[3]_12 NBL[3]_14 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAE_0 SAE_1
+  SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5
+  SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 SO TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VPW WENL WENR WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3 RAMSP4096X16IOCDM_L
XIO_EDGE_L ADDR BLPRECH DFTRAMBYP DWL LOG0_1 NACT_CC NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL VDDCE VDDCE
+  VDDPE VDDCE VPW VPW WENL YW0 YW1 YW2 YW3 RAMSP4096X16IOEDGE
XIO_RDM_ROW_L DWL_L DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 IADDR_0 IADDR_1
+  IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7 IADDR_NSAE_0 IADDR_NSAE_1
+  IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4 IADDR_NSAE_5 IADDR_NSAE_6
+  IADDR_NSAE_7 NADDR_0 NADDR_1 NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6
+  NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1 NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4
+  NADDR_NSAE_5 NADDR_NSAE_6 NADDR_NSAE_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1 SAO_2 SAO_3
+  SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0
+  TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4
+  WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  RAMSP4096X16IO_RDM_L
XIO_TOPCAP_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9
+  BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8
+  NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14
+  NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW RAMSP4096X16IOTOPCAP_L
.ENDS RAMSP4096X16IO_ROW_L
****
.SUBCKT RAMSP4096X16CKM8_BIST ACTP ADDR BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0
+  CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAMBYP DFTRAM_RET DUMMY_DWL_L
+  DUMMY_DWL_R DUMMY_WL DUM_NWCLK DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0
+  DUM_PSO1 DUM_TPEN DWL DWL_WDX EMAW[0] EMAW[1] EMA[0] EMA[1] EMA[2] FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT
+  NSAE NSAO_L NSAO_R NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 RA0 RA1 RA2 RA3 RA4
+  RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3]
+  RA_P2[4] RA_P2[5] RDT RET RET1N SAE_DUMMY SAPRECH SE SEL_D SEL_SI SEL_TD
+  SO0 SO1 TCA0 TCA1 TCA2 TCEN TE TEN TGWEN TLA0 TLA1 TLA2 TRA0 TRA1 TRA2 TRA3
+  TRA4 TRA5 TWEN VDDCE VDDC_L VDDC_LEFT VDDC_R VDDC_RIGHT VDDP VDDPE
+  VDDP_CLKGEN VNWC VNWP VPW VSS VSSE WEN WR_THRU YW0 YW1 YW2 YW3
** RAMSP4096X16CKM8_BIST: 831 flat devices **
X_MI102.MXNA1 NTE TE VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MI102.MXPA1 NTE TE VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI107.I2.MXNA1 SEL_SI I107.NSE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I2.MXPA1 SEL_SI I107.NSE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I4.MXNA1 SEL_TD I107.NET18 VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I4.MXPA1 SEL_TD I107.NET18 VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I5.MXNA1 SEL_D I107.TE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I5.MXPA1 SEL_D I107.TE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I7.MXNA1 I107.NSE SE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI107.I7.MXPA1 I107.NSE SE VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI107.I8.MXNA1 I107.NET18 I107.NSE I107.I8.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXNA2 I107.I8.N1 I107.TE VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA1 I107.NET18 I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA2 I107.NET18 I107.TE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA1 I107.TE I107.NSE I107.I83.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA2 I107.I83.N1 TEN VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA1 I107.TE I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA2 I107.TE TEN VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI111.MXNA1 INTE TE VSS VPW N11LL_CKT W=1.83U L=0.04U
X_MI111.MXPA1 INTE TE VDDPE VNWP P11LL_CKT W=2.765U L=0.04U
X_MI115.MXNA1 NRDT_RD GWEN_P2 I115.N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA2 I115.N2 RET1N I115.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA3 I115.N1 RDT_P2 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXPA1 NRDT_RD GWEN_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA2 NRDT_RD RET1N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA3 NRDT_RD RDT_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI116_0.MXNA1 SO0 NET470[1] VSS VPW N11LL_CKT W=0.56U L=0.04U
X_MI116_0.MXPA1 SO0 NET470[1] VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MI116_1.MXNA1 SO1 NET470[0] VSS VPW N11LL_CKT W=0.56U L=0.04U
X_MI116_1.MXPA1 SO1 NET470[0] VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MI117.MXNA1 IDFTRAMBYP NDFTRAMBYP VSS VPW N11LL_CKT W=1.065U L=0.04U
X_MI117.MXPA1 IDFTRAMBYP NDFTRAMBYP VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MI118.MXNA1 NDFTRAMBYP DFTRAMBYP VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI118.MXPA1 NDFTRAMBYP DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI12.MXNA1 NDY CEN_P2 I12.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXNA2 I12.N1 IDFTRAMBYP VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA1 NDY CEN_P2 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA2 NDY IDFTRAMBYP VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI120.MXNA1 RDT_RD NRDT_RD VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_MI120.MXPA1 RDT_RD NRDT_RD VDDPE VNWP P11LL_CKT W=0.79U L=0.04U
X_MI123.MXNA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI123.MXPA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.43U
+  L=0.04U
X_MI127._addr_lat.I0.MXNA1 I127._ADDR_LAT.NDY I127._ADDR_LAT.IDY
+  I127._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI127._addr_lat.I0.MXNA2 I127._ADDR_LAT.I0.N1 IDFTRAMBYP VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MI127._addr_lat.I0.MXPA1 I127._ADDR_LAT.NDY I127._ADDR_LAT.IDY VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_MI127._addr_lat.I0.MXPA2 I127._ADDR_LAT.NDY IDFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MI127._addr_lat.I50.MXNA1 CA_P2[2] NCA_P2[2] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MI127._addr_lat.I50.MXPA1 CA_P2[2] NCA_P2[2] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MI127._addr_lat.I55.MXNA1 I127._ADDR_LAT.I55.N1 CA_P2[2] VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MI127._addr_lat.I55.MXNOE NCA_P2[2] BCLK_GTPSA I127._ADDR_LAT.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MI127._addr_lat.I55.MXPA1 I127._ADDR_LAT.I55.P1 CA_P2[2] VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MI127._addr_lat.I55.MXPOEN NCA_P2[2] NCLK_GTPSA I127._ADDR_LAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MI127._addr_lat.I62.MXNA1 CAY2 I127._ADDR_LAT.NDY VSS VPW N11LL_CKT W=0.5U
+  L=0.04U
X_MI127._addr_lat.I62.MXPA1 CAY2 I127._ADDR_LAT.NDY VDDPE VNWP P11LL_CKT
+  W=1.12U L=0.04U
X_MI127._addr_lat.I63.MXNA1 I127._ADDR_LAT.IDY I127._ADDR_LAT.ND VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MI127._addr_lat.I63.MXPA1 I127._ADDR_LAT.IDY I127._ADDR_LAT.ND VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_MI127._addr_lat.I65.MXNOE NCA_P2[2] NCLK_GTPSA I127._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_MI127._addr_lat.I65.MXPOEN NCA_P2[2] BCLK_GTPSA I127._ADDR_LAT.ND VNWP
+  P11LL_CKT W=0.34U L=0.04U
X_MI127._addr_lat.MXN1 I127._ADDR_LAT.ND TCA2 I127._ADDR_LAT.N2 VPW N11LL_CKT
+  W=0.35U L=0.04U
X_MI127._addr_lat.MXN2 I127._ADDR_LAT.ND CA2 I127._ADDR_LAT.N1 VPW N11LL_CKT
+  W=0.7U L=0.04U
X_MI127._addr_lat.MXN5 I127._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT W=0.7U L=0.04U
X_MI127._addr_lat.MXN6 I127._ADDR_LAT.N2 TE VSS VPW N11LL_CKT W=0.35U L=0.04U
X_MI127._addr_lat.MXP1 I127._ADDR_LAT.ND CA2 I127._ADDR_LAT.P1 VNWP P11LL_CKT
+  W=1.02U L=0.04U
X_MI127._addr_lat.MXP3 I127._ADDR_LAT.ND TCA2 I127._ADDR_LAT.P2 VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_MI127._addr_lat.MXP4 I127._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_MI127._addr_lat.MXP5 I127._ADDR_LAT.P2 INTE VDDPE VNWP P11LL_CKT W=0.51U
+  L=0.04U
X_MI129.MXNA1 ISAPRECH GTP VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI129.MXNA2 ISAPRECH GTPSA_SPLIT VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI129.MXPA1 ISAPRECH GTP I129.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_MI129.MXPA2 I129.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI130_0.MXNA1 CADDR0 NCADDR0 VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_0.MXPA1 CADDR0 NCADDR0 VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI130_1.MXNA1 CADDR1 NCADDR1 VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_1.MXPA1 CADDR1 NCADDR1 VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI131.MXNA1 BCLK_CA2 NCLK_CA2 VSS VPW N11LL_CKT W=0.21U L=0.04U
X_MI131.MXPA1 BCLK_CA2 NCLK_CA2 VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI132.MXN0 I132.NET104 I132.NET116 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI132.MXN1 I132.NET135 DWL_WDX VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI132.MXN2 I132.NET112 I132.NET135 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI132.MXN3 VSS I132.NET104 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI132.MXN4 I132.NET116 I132.NET135 I132.NET112 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MI132.MXN8 DLY_DWL I132.NET104 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI132.MXP0 DLY_DWL I132.NET104 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI132.MXP1 I132.NET123 I132.NET116 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI132.MXP2 I132.NET104 I132.NET116 I132.NET123 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_MI132.MXP3 I132.NET135 DWL_WDX VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI132.MXP5 I132.NET116 I132.NET135 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI134.MXNA1 NET0570 RET1N I134.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXNA2 I134.N1 NDFTRAMBYP_LAT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA1 NET0570 RET1N VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA2 NET0570 NDFTRAMBYP_LAT VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI135.MXNA1 DFTRAM_NRET NET0570 VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI135.MXPA1 DFTRAM_NRET NET0570 VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI136.MXNA1 RET1N_WEMA00N NET0630 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI136.MXPA1 RET1N_WEMA00N NET0630 VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI137_0.MXNA1 I137_0.N1 CA_P2[0] VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI137_0.MXNOE NCADDR0 CA_P2[0] I137_0.N1 VPW N11LL_CKT W=0.355U L=0.04U
X_MI137_0.MXPA1 I137_0.P1 CA_P2[0] VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI137_0.MXPOEN NCADDR0 CA_P2[0] I137_0.P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MI137_1.MXNA1 I137_1.N1 CA_P2[1] VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI137_1.MXNOE NCADDR1 CA_P2[1] I137_1.N1 VPW N11LL_CKT W=0.355U L=0.04U
X_MI137_1.MXPA1 I137_1.P1 CA_P2[1] VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI137_1.MXPOEN NCADDR1 CA_P2[1] I137_1.P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MI138.MXNA1 RET RET1N VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI138.MXPA1 RET RET1N VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI140.MXNA1 NET0585 GTP VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI140.MXNA2 NET0585 GTPSA_SPLIT VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI140.MXPA1 NET0585 GTP I140.P1 VNWP P11LL_CKT W=0.6U L=0.04U
X_MI140.MXPA2 I140.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI151.MXNA1 NET0581 INSAE VSS VPW N11LL_CKT W=0.25U L=0.04U
X_MI151.MXPA1 NET0581 INSAE VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI152.MXNA1 INSAE_DLY NET0581 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI152.MXPA1 INSAE_DLY NET0581 VDDPE VNWP P11LL_CKT W=0.55U L=0.04U
X_MI1521.MXNA1 CEN_P2 NET377 VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MI1521.MXPA1 CEN_P2 NET377 VDDPE VNWP P11LL_CKT W=1.275U L=0.04U
X_MI155_0.MXNA1 NET470[1] NSAO_L VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI155_0.MXPA1 NET470[1] NSAO_L VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI155_1.MXNA1 NET470[0] NSAO_R VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI155_1.MXPA1 NET470[0] NSAO_R VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI163.MXNA1 WEMA00 EMAW[0] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI163.MXNA2 WEMA00 EMAW[1] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI163.MXPA1 WEMA00 EMAW[0] I163.P1 VNWP P11LL_CKT W=0.17U L=0.04U
X_MI163.MXPA2 I163.P1 EMAW[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI164.MXNA1 WEMA00_N WEMA00 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI164.MXPA1 WEMA00_N WEMA00 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI22.MXNA1 NET0630 RET1N I22.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MI22.MXNA2 I22.N1 WEMA00_N VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI22.MXPA1 NET0630 RET1N VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI22.MXPA2 NET0630 WEMA00_N VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI237.MXNA1 NCLK_GTPSA BCLK_GTPSA VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MI237.MXPA1 NCLK_GTPSA BCLK_GTPSA VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI28.MXNA1 BCLK_GTPSA NET0585 I28.N1 VPW N11LL_CKT W=0.45U L=0.04U
X_MI28.MXNA2 I28.N1 WRITE_NGTP VSS VPW N11LL_CKT W=0.45U L=0.04U
X_MI28.MXPA1 BCLK_GTPSA NET0585 VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI28.MXPA2 BCLK_GTPSA WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI32.MXNA1 NCLK GTP VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI32.MXPA1 NCLK GTP VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI4.MXNA1 NICLK GTP VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI4.MXPA1 NICLK GTP VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MI5.MXNA1 BCLK NICLK VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI5.MXPA1 BCLK NICLK VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI50.MXNA1 IWCLK_WT INWCLK_WT VSS VPW N11LL_CKT W=0.99U L=0.04U
X_MI50.MXPA1 IWCLK_WT INWCLK_WT VDDPE VNWP P11LL_CKT W=1.995U L=0.04U
X_MI51.MXNA1 NGTP GTP VSS VPW N11LL_CKT W=0.855U L=0.04U
X_MI51.MXPA1 NGTP GTP VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_MI52.MXNA1 DFTRAM_RET DFTRAM_NRET VSSE VPW N11LL_CKT W=3.55U L=0.04U
X_MI52.MXPA1 DFTRAM_RET DFTRAM_NRET VDDCE VNWC P11LL_CKT W=7.1U L=0.04U
X_MI53.MXNA1 NCLK_CA2 GWEN_LAT_Q I53.A1A2 VPW N11LL_CKT W=0.285U L=0.04U
X_MI53.MXNA2 I53.A1A2 BCLK_GTPSA VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI53.MXNB1 NCLK_CA2 BCLK VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI53.MXPA1 NCLK_CA2 GWEN_LAT_Q I53.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_MI53.MXPA2 NCLK_CA2 BCLK_GTPSA I53.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_MI53.MXPB1 I53.A1A2UP BCLK VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI62.MXNA1 CENY NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI62.MXPA1 CENY NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MI63.MXNA1 NGWE_DFT GWE_P2 VSS VPW N11LL_CKT W=0.415U L=0.04U
X_MI63.MXNA2 NGWE_DFT DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.415U L=0.04U
X_MI63.MXPA1 NGWE_DFT GWE_P2 I63.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_MI63.MXPA2 I63.P1 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI64.MXNA1 NSAPRECH ISAPRECH VSS VPW N11LL_CKT W=1.41U L=0.04U
X_MI64.MXPA1 NSAPRECH ISAPRECH VDDPE VNWP P11LL_CKT W=2.835U L=0.04U
X_MI77.MXN0 VSSE I77.NET19 I77.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI77.MXN2 VPW I77.NET15 I77.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI77.MXN3 VPW I77.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI81.MXNA1 INSAE GTPSA_SPLIT I81.N1 VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXNA2 I81.N1 NGWE_DFT VSS VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXPA1 INSAE GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI81.MXPA2 INSAE NGWE_DFT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI84.MXNA1 NWCLK_WT IWCLK_WT VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MI84.MXPA1 NWCLK_WT IWCLK_WT VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MI90.MXNA1 ADDR NADDR VSS VPW N11LL_CKT W=3.55U L=0.04U
X_MI90.MXPA1 ADDR NADDR VDDPE VNWP P11LL_CKT W=7.315U L=0.04U
X_MI91.MXNA1 NADDR CA_P2[2] VSS VPW N11LL_CKT W=1.06U L=0.04U
X_MI91.MXPA1 NADDR CA_P2[2] VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MI96.MXN0 VSSE I96.NET19 I96.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI96.MXN2 VPW I96.NET15 I96.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI96.MXN3 VPW I96.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI97.MXNA1 TE TEN VSS VPW N11LL_CKT W=2.275U L=0.04U
X_MI97.MXPA1 TE TEN VDDPE VNWP P11LL_CKT W=4.27U L=0.04U
X_MIV_ALat.MXNA1 GWEN_P2 GWE_P2 VSS VPW N11LL_CKT W=0.59U L=0.04U
X_MIV_ALat.MXPA1 GWEN_P2 GWE_P2 VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MIV_nALat.MXNA1 GWE_P2 GWEN_LAT_Q VSS VPW N11LL_CKT W=0.75U L=0.04U
X_MIV_nALat.MXPA1 GWE_P2 GWEN_LAT_Q VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MXN0 NSAE SAE VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN1 NET377 TCEN N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN2 NET377 CEN N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN4 SAE INSAE NET0506 VPW N11LL_CKT W=0.925U L=0.04U
X_MXN5 N1 NTE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN6 N2 TE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN7 SAPRECH NSAPRECH VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN8 NET0506 INSAE_DLY VSS VPW N11LL_CKT W=0.925U L=0.04U
X_MXP0 NSAE SAE VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_MXP1 NET377 CEN P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP2 SAE INSAE_DLY VDDPE VNWP P11LL_CKT W=1.705U L=0.04U
X_MXP3 NET377 TCEN P2 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP4 P1 TE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP5 P2 NTE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP6 SAE INSAE VDDPE VNWP P11LL_CKT W=1.705U L=0.04U
X_MXP7 SAPRECH NSAPRECH VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY _ADDR_LAT_0._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA2 _ADDR_LAT_0._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA2 _ADDR_LAT_0._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXNA1 CA_P2[0] NCA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXPA1 CA_P2[0] NCA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNA1 _ADDR_LAT_0._ADDR_LAT.I55.N1 CA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNOE NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPA1 _ADDR_LAT_0._ADDR_LAT.I55.P1 CA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPOEN NCA_P2[0] NCLK
+  _ADDR_LAT_0._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXNA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXPA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXNA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXPA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXNOE NCA_P2[0] NCLK _ADDR_LAT_0._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXPOEN NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.MXN1 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN2 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN5 _ADDR_LAT_0._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN6 _ADDR_LAT_0._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXP1 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP3 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP4 _ADDR_LAT_0._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP5 _ADDR_LAT_0._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY _ADDR_LAT_1._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA2 _ADDR_LAT_1._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA2 _ADDR_LAT_1._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXNA1 CA_P2[1] NCA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXPA1 CA_P2[1] NCA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNA1 _ADDR_LAT_1._ADDR_LAT.I55.N1 CA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNOE NCA_P2[1] BCLK _ADDR_LAT_1._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPA1 _ADDR_LAT_1._ADDR_LAT.I55.P1 CA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPOEN NCA_P2[1] NCLK
+  _ADDR_LAT_1._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXNA1 CAY1 _ADDR_LAT_1._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXPA1 CAY1 _ADDR_LAT_1._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXNA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXPA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXNOE NCA_P2[1] NCLK _ADDR_LAT_1._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXPOEN NCA_P2[1] BCLK _ADDR_LAT_1._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.MXN1 _ADDR_LAT_1._ADDR_LAT.ND TCA1
+  _ADDR_LAT_1._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN2 _ADDR_LAT_1._ADDR_LAT.ND CA1
+  _ADDR_LAT_1._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN5 _ADDR_LAT_1._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN6 _ADDR_LAT_1._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXP1 _ADDR_LAT_1._ADDR_LAT.ND CA1
+  _ADDR_LAT_1._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP3 _ADDR_LAT_1._ADDR_LAT.ND TCA1
+  _ADDR_LAT_1._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP4 _ADDR_LAT_1._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP5 _ADDR_LAT_1._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_10._addr_lat.I0.MXNA1 _ADDR_LAT_10._ADDR_LAT.NDY
+  _ADDR_LAT_10._ADDR_LAT.IDY _ADDR_LAT_10._ADDR_LAT.I0.N1 VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_addr_lat_10._addr_lat.I0.MXNA2 _ADDR_LAT_10._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_10._addr_lat.I0.MXPA1 _ADDR_LAT_10._ADDR_LAT.NDY
+  _ADDR_LAT_10._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_10._addr_lat.I0.MXPA2 _ADDR_LAT_10._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_10._addr_lat.I50.MXNA1 LA_P2[1] NLA_P2[1] VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_addr_lat_10._addr_lat.I50.MXPA1 LA_P2[1] NLA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_10._addr_lat.I55.MXNA1 _ADDR_LAT_10._ADDR_LAT.I55.N1 LA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_10._addr_lat.I55.MXNOE NLA_P2[1] BCLK
+  _ADDR_LAT_10._ADDR_LAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_10._addr_lat.I55.MXPA1 _ADDR_LAT_10._ADDR_LAT.I55.P1 LA_P2[1]
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_10._addr_lat.I55.MXPOEN NLA_P2[1] NCLK
+  _ADDR_LAT_10._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_10._addr_lat.I62.MXNA1 LAY1 _ADDR_LAT_10._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_10._addr_lat.I62.MXPA1 LAY1 _ADDR_LAT_10._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_10._addr_lat.I63.MXNA1 _ADDR_LAT_10._ADDR_LAT.IDY
+  _ADDR_LAT_10._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_10._addr_lat.I63.MXPA1 _ADDR_LAT_10._ADDR_LAT.IDY
+  _ADDR_LAT_10._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_10._addr_lat.I65.MXNOE NLA_P2[1] NCLK _ADDR_LAT_10._ADDR_LAT.ND
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_10._addr_lat.I65.MXPOEN NLA_P2[1] BCLK _ADDR_LAT_10._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_10._addr_lat.MXN1 _ADDR_LAT_10._ADDR_LAT.ND TLA1
+  _ADDR_LAT_10._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_10._addr_lat.MXN2 _ADDR_LAT_10._ADDR_LAT.ND LA1
+  _ADDR_LAT_10._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_10._addr_lat.MXN5 _ADDR_LAT_10._ADDR_LAT.N1 INTE VSS VPW
+  N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_10._addr_lat.MXN6 _ADDR_LAT_10._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_10._addr_lat.MXP1 _ADDR_LAT_10._ADDR_LAT.ND LA1
+  _ADDR_LAT_10._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_10._addr_lat.MXP3 _ADDR_LAT_10._ADDR_LAT.ND TLA1
+  _ADDR_LAT_10._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_10._addr_lat.MXP4 _ADDR_LAT_10._ADDR_LAT.P1 TE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_10._addr_lat.MXP5 _ADDR_LAT_10._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_11._addr_lat.I0.MXNA1 _ADDR_LAT_11._ADDR_LAT.NDY
+  _ADDR_LAT_11._ADDR_LAT.IDY _ADDR_LAT_11._ADDR_LAT.I0.N1 VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_addr_lat_11._addr_lat.I0.MXNA2 _ADDR_LAT_11._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_11._addr_lat.I0.MXPA1 _ADDR_LAT_11._ADDR_LAT.NDY
+  _ADDR_LAT_11._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_11._addr_lat.I0.MXPA2 _ADDR_LAT_11._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_11._addr_lat.I50.MXNA1 LA_P2[2] NLA_P2[2] VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_addr_lat_11._addr_lat.I50.MXPA1 LA_P2[2] NLA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_11._addr_lat.I55.MXNA1 _ADDR_LAT_11._ADDR_LAT.I55.N1 LA_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_11._addr_lat.I55.MXNOE NLA_P2[2] BCLK
+  _ADDR_LAT_11._ADDR_LAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_11._addr_lat.I55.MXPA1 _ADDR_LAT_11._ADDR_LAT.I55.P1 LA_P2[2]
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_11._addr_lat.I55.MXPOEN NLA_P2[2] NCLK
+  _ADDR_LAT_11._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_11._addr_lat.I62.MXNA1 LAY2 _ADDR_LAT_11._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_11._addr_lat.I62.MXPA1 LAY2 _ADDR_LAT_11._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_11._addr_lat.I63.MXNA1 _ADDR_LAT_11._ADDR_LAT.IDY
+  _ADDR_LAT_11._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_11._addr_lat.I63.MXPA1 _ADDR_LAT_11._ADDR_LAT.IDY
+  _ADDR_LAT_11._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_11._addr_lat.I65.MXNOE NLA_P2[2] NCLK _ADDR_LAT_11._ADDR_LAT.ND
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_11._addr_lat.I65.MXPOEN NLA_P2[2] BCLK _ADDR_LAT_11._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_11._addr_lat.MXN1 _ADDR_LAT_11._ADDR_LAT.ND TLA2
+  _ADDR_LAT_11._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_11._addr_lat.MXN2 _ADDR_LAT_11._ADDR_LAT.ND LA2
+  _ADDR_LAT_11._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_11._addr_lat.MXN5 _ADDR_LAT_11._ADDR_LAT.N1 INTE VSS VPW
+  N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_11._addr_lat.MXN6 _ADDR_LAT_11._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_11._addr_lat.MXP1 _ADDR_LAT_11._ADDR_LAT.ND LA2
+  _ADDR_LAT_11._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_11._addr_lat.MXP3 _ADDR_LAT_11._ADDR_LAT.ND TLA2
+  _ADDR_LAT_11._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_11._addr_lat.MXP4 _ADDR_LAT_11._ADDR_LAT.P1 TE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_11._addr_lat.MXP5 _ADDR_LAT_11._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY _ADDR_LAT_2._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA2 _ADDR_LAT_2._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA2 _ADDR_LAT_2._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXNA1 LA_P2[0] NCA_P2[3] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXPA1 LA_P2[0] NCA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNA1 _ADDR_LAT_2._ADDR_LAT.I55.N1 LA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNOE NCA_P2[3] BCLK _ADDR_LAT_2._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPA1 _ADDR_LAT_2._ADDR_LAT.I55.P1 LA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPOEN NCA_P2[3] NCLK
+  _ADDR_LAT_2._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXNA1 LAY0 _ADDR_LAT_2._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXPA1 LAY0 _ADDR_LAT_2._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXNA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXPA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXNOE NCA_P2[3] NCLK _ADDR_LAT_2._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXPOEN NCA_P2[3] BCLK _ADDR_LAT_2._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.MXN1 _ADDR_LAT_2._ADDR_LAT.ND TLA0
+  _ADDR_LAT_2._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN2 _ADDR_LAT_2._ADDR_LAT.ND LA0
+  _ADDR_LAT_2._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN5 _ADDR_LAT_2._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN6 _ADDR_LAT_2._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXP1 _ADDR_LAT_2._ADDR_LAT.ND LA0
+  _ADDR_LAT_2._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP3 _ADDR_LAT_2._ADDR_LAT.ND TLA0
+  _ADDR_LAT_2._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP4 _ADDR_LAT_2._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP5 _ADDR_LAT_2._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY _ADDR_LAT_4._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA2 _ADDR_LAT_4._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA2 _ADDR_LAT_4._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXNA1 RA_P2[0] NRA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXPA1 RA_P2[0] NRA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNA1 _ADDR_LAT_4._ADDR_LAT.I55.N1 RA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNOE NRA_P2[0] BCLK _ADDR_LAT_4._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPA1 _ADDR_LAT_4._ADDR_LAT.I55.P1 RA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPOEN NRA_P2[0] NCLK
+  _ADDR_LAT_4._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXNA1 RAY0 _ADDR_LAT_4._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXPA1 RAY0 _ADDR_LAT_4._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXNA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXPA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXNOE NRA_P2[0] NCLK _ADDR_LAT_4._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXPOEN NRA_P2[0] BCLK _ADDR_LAT_4._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.MXN1 _ADDR_LAT_4._ADDR_LAT.ND TRA0
+  _ADDR_LAT_4._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN2 _ADDR_LAT_4._ADDR_LAT.ND RA0
+  _ADDR_LAT_4._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN5 _ADDR_LAT_4._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN6 _ADDR_LAT_4._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXP1 _ADDR_LAT_4._ADDR_LAT.ND RA0
+  _ADDR_LAT_4._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP3 _ADDR_LAT_4._ADDR_LAT.ND TRA0
+  _ADDR_LAT_4._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP4 _ADDR_LAT_4._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP5 _ADDR_LAT_4._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY _ADDR_LAT_5._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA2 _ADDR_LAT_5._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA2 _ADDR_LAT_5._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXNA1 RA_P2[1] NRA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXPA1 RA_P2[1] NRA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNA1 _ADDR_LAT_5._ADDR_LAT.I55.N1 RA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNOE NRA_P2[1] BCLK _ADDR_LAT_5._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPA1 _ADDR_LAT_5._ADDR_LAT.I55.P1 RA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPOEN NRA_P2[1] NCLK
+  _ADDR_LAT_5._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXNA1 RAY1 _ADDR_LAT_5._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXPA1 RAY1 _ADDR_LAT_5._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXNA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXPA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXNOE NRA_P2[1] NCLK _ADDR_LAT_5._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXPOEN NRA_P2[1] BCLK _ADDR_LAT_5._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.MXN1 _ADDR_LAT_5._ADDR_LAT.ND TRA1
+  _ADDR_LAT_5._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN2 _ADDR_LAT_5._ADDR_LAT.ND RA1
+  _ADDR_LAT_5._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN5 _ADDR_LAT_5._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN6 _ADDR_LAT_5._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXP1 _ADDR_LAT_5._ADDR_LAT.ND RA1
+  _ADDR_LAT_5._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP3 _ADDR_LAT_5._ADDR_LAT.ND TRA1
+  _ADDR_LAT_5._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP4 _ADDR_LAT_5._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP5 _ADDR_LAT_5._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY _ADDR_LAT_6._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA2 _ADDR_LAT_6._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA2 _ADDR_LAT_6._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXNA1 RA_P2[2] NRA_P2[2] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXPA1 RA_P2[2] NRA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNA1 _ADDR_LAT_6._ADDR_LAT.I55.N1 RA_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNOE NRA_P2[2] BCLK _ADDR_LAT_6._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPA1 _ADDR_LAT_6._ADDR_LAT.I55.P1 RA_P2[2] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPOEN NRA_P2[2] NCLK
+  _ADDR_LAT_6._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXNA1 RAY2 _ADDR_LAT_6._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXPA1 RAY2 _ADDR_LAT_6._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXNA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXPA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXNOE NRA_P2[2] NCLK _ADDR_LAT_6._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXPOEN NRA_P2[2] BCLK _ADDR_LAT_6._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.MXN1 _ADDR_LAT_6._ADDR_LAT.ND TRA2
+  _ADDR_LAT_6._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN2 _ADDR_LAT_6._ADDR_LAT.ND RA2
+  _ADDR_LAT_6._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN5 _ADDR_LAT_6._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN6 _ADDR_LAT_6._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXP1 _ADDR_LAT_6._ADDR_LAT.ND RA2
+  _ADDR_LAT_6._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP3 _ADDR_LAT_6._ADDR_LAT.ND TRA2
+  _ADDR_LAT_6._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP4 _ADDR_LAT_6._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP5 _ADDR_LAT_6._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY _ADDR_LAT_7._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA2 _ADDR_LAT_7._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA2 _ADDR_LAT_7._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXNA1 RA_P2[3] NRA_P2[3] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXPA1 RA_P2[3] NRA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNA1 _ADDR_LAT_7._ADDR_LAT.I55.N1 RA_P2[3] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNOE NRA_P2[3] BCLK _ADDR_LAT_7._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPA1 _ADDR_LAT_7._ADDR_LAT.I55.P1 RA_P2[3] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPOEN NRA_P2[3] NCLK
+  _ADDR_LAT_7._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXNA1 RAY3 _ADDR_LAT_7._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXPA1 RAY3 _ADDR_LAT_7._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXNA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXPA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXNOE NRA_P2[3] NCLK _ADDR_LAT_7._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXPOEN NRA_P2[3] BCLK _ADDR_LAT_7._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.MXN1 _ADDR_LAT_7._ADDR_LAT.ND TRA3
+  _ADDR_LAT_7._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN2 _ADDR_LAT_7._ADDR_LAT.ND RA3
+  _ADDR_LAT_7._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN5 _ADDR_LAT_7._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN6 _ADDR_LAT_7._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXP1 _ADDR_LAT_7._ADDR_LAT.ND RA3
+  _ADDR_LAT_7._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP3 _ADDR_LAT_7._ADDR_LAT.ND TRA3
+  _ADDR_LAT_7._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP4 _ADDR_LAT_7._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP5 _ADDR_LAT_7._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY _ADDR_LAT_8._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA2 _ADDR_LAT_8._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA2 _ADDR_LAT_8._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXNA1 RA_P2[4] NRA_P2[4] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXPA1 RA_P2[4] NRA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNA1 _ADDR_LAT_8._ADDR_LAT.I55.N1 RA_P2[4] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNOE NRA_P2[4] BCLK _ADDR_LAT_8._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPA1 _ADDR_LAT_8._ADDR_LAT.I55.P1 RA_P2[4] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPOEN NRA_P2[4] NCLK
+  _ADDR_LAT_8._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXNA1 RAY4 _ADDR_LAT_8._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXPA1 RAY4 _ADDR_LAT_8._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXNA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXPA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXNOE NRA_P2[4] NCLK _ADDR_LAT_8._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXPOEN NRA_P2[4] BCLK _ADDR_LAT_8._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.MXN1 _ADDR_LAT_8._ADDR_LAT.ND TRA4
+  _ADDR_LAT_8._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN2 _ADDR_LAT_8._ADDR_LAT.ND RA4
+  _ADDR_LAT_8._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN5 _ADDR_LAT_8._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN6 _ADDR_LAT_8._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXP1 _ADDR_LAT_8._ADDR_LAT.ND RA4
+  _ADDR_LAT_8._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP3 _ADDR_LAT_8._ADDR_LAT.ND TRA4
+  _ADDR_LAT_8._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP4 _ADDR_LAT_8._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP5 _ADDR_LAT_8._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXNA1 _ADDR_LAT_9._ADDR_LAT.NDY
+  _ADDR_LAT_9._ADDR_LAT.IDY _ADDR_LAT_9._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXNA2 _ADDR_LAT_9._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXPA1 _ADDR_LAT_9._ADDR_LAT.NDY
+  _ADDR_LAT_9._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXPA2 _ADDR_LAT_9._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I50.MXNA1 RA_P2[5] NRA_P2[5] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_9._addr_lat.I50.MXPA1 RA_P2[5] NRA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXNA1 _ADDR_LAT_9._ADDR_LAT.I55.N1 RA_P2[5] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXNOE NRA_P2[5] BCLK _ADDR_LAT_9._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXPA1 _ADDR_LAT_9._ADDR_LAT.I55.P1 RA_P2[5] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXPOEN NRA_P2[5] NCLK
+  _ADDR_LAT_9._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I62.MXNA1 RAY5 _ADDR_LAT_9._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_9._addr_lat.I62.MXPA1 RAY5 _ADDR_LAT_9._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_9._addr_lat.I63.MXNA1 _ADDR_LAT_9._ADDR_LAT.IDY
+  _ADDR_LAT_9._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I63.MXPA1 _ADDR_LAT_9._ADDR_LAT.IDY
+  _ADDR_LAT_9._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I65.MXNOE NRA_P2[5] NCLK _ADDR_LAT_9._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_9._addr_lat.I65.MXPOEN NRA_P2[5] BCLK _ADDR_LAT_9._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_9._addr_lat.MXN1 _ADDR_LAT_9._ADDR_LAT.ND TRA5
+  _ADDR_LAT_9._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN2 _ADDR_LAT_9._ADDR_LAT.ND RA5
+  _ADDR_LAT_9._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN5 _ADDR_LAT_9._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN6 _ADDR_LAT_9._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXP1 _ADDR_LAT_9._ADDR_LAT.ND RA5
+  _ADDR_LAT_9._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP3 _ADDR_LAT_9._ADDR_LAT.ND TRA5
+  _ADDR_LAT_9._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP4 _ADDR_LAT_9._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP5 _ADDR_LAT_9._ADDR_LAT.P2 INTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_blprech.I51.MXNA1 _BLPRECH.DGTP_L _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXNA2 _BLPRECH.DGTP_L _BLPRECH.DRET VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXPA1 _BLPRECH.DGTP_L _BLPRECH.IGTP _BLPRECH.I51.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I51.MXPA2 _BLPRECH.I51.P1 _BLPRECH.DRET VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_blprech.I52.MXNA1 _BLPRECH.DGTP_R _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I52.MXNA2 _BLPRECH.DGTP_R RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I52.MXPA1 _BLPRECH.DGTP_R _BLPRECH.IGTP _BLPRECH.I52.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I52.MXPA2 _BLPRECH.I52.P1 RET VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I64.MXNA1 _BLPRECH.I64.N1 _BLPRECH.NET039 VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_blprech.I64.MXNOE _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_blprech.I64.MXPA1 _BLPRECH.I64.P1 _BLPRECH.NET039 VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_blprech.I64.MXPOEN _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_blprech.I65.MXNA1 _BLPRECH.I65.N1 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I65.MXNOE _BLPRECH.NET039 RET _BLPRECH.I65.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I65.MXPA1 _BLPRECH.I65.P1 RET VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_blprech.I65.MXPOEN _BLPRECH.NET039 RET _BLPRECH.I65.P1 VNWP P11LL_CKT
+  W=0.43U L=0.04U
X_M_blprech.I68.MXNA1 _BLPRECH.DRET _BLPRECH.NET49 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_blprech.I68.MXPA1 _BLPRECH.DRET _BLPRECH.NET49 VDDPE VNWP P11LL_CKT
+  W=0.345U L=0.04U
X_M_blprech.I69.MXNA1 _BLPRECH.NET49 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I69.MXNA2 _BLPRECH.NET49 _BLPRECH.NET047 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA1 _BLPRECH.NET49 RET _BLPRECH.I69.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA2 _BLPRECH.I69.P1 _BLPRECH.NET047 VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.MXN0 BLPRECH_R _BLPRECH.NBLPRECH_R VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN1 BLPRECH_L _BLPRECH.NBLPRECH_L VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN2 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXN4 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXP0 VDDPE RDT_RD VDDPE VNWP P11LL_CKT W=4.095U L=0.04U
X_M_blprech.MXP2 BLPRECH_R _BLPRECH.NBLPRECH_R VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP3 BLPRECH_L _BLPRECH.NBLPRECH_L VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP4 _BLPRECH.IGTP NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_blprech._aoi_bl_f.MXN0 _BLPRECH.NBLPRECH_L NGTP _BLPRECH._AOI_BL_F.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN1 _BLPRECH._AOI_BL_F.NET12 _BLPRECH.DGTP_L VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN2 _BLPRECH.NBLPRECH_L RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_f.MXP0 _BLPRECH.NBLPRECH_L NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_f.MXP1 _BLPRECH.NBLPRECH_L _BLPRECH.DGTP_L VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXN0 _BLPRECH.NBLPRECH_R NGTP _BLPRECH._AOI_BL_R.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN1 _BLPRECH._AOI_BL_R.NET12 _BLPRECH.DGTP_R VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN2 _BLPRECH.NBLPRECH_R RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_r.MXP0 _BLPRECH.NBLPRECH_R NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXP1 _BLPRECH.NBLPRECH_R _BLPRECH.DGTP_R VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_ckgen.I92.MXNA1 DWL _CKGEN.NGTP VSSE VPW N11LL_CKT W=4.26U L=0.04U
X_M_ckgen.I92.MXPA1 DWL _CKGEN.NGTP VDDP_CLKGEN VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckgen.Iema.I0.MXNA1 _CKGEN.IEMA.NGWE GWE_DFT _CKGEN.IEMA.I0.N1 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckgen.Iema.I0.MXNA2 _CKGEN.IEMA.I0.N1 RET1N_WEMA00N VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I0.MXPA1 _CKGEN.IEMA.NGWE GWE_DFT VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_ckgen.Iema.I0.MXPA2 _CKGEN.IEMA.NGWE RET1N_WEMA00N VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I1.MXNA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I1.MXPA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=1.28U L=0.04U
X_M_ckgen.Iema.I2.MXNA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I2.MXPA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_ckgen.Iema.I20.MXNOE _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NRDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I20.MXPOEN _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NRDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXNOE _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NWDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXPOEN _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NWDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I40.MXNA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I40.MXPA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.I49.MXN3 _CKGEN.IEMA.I49.NET057 GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET049 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN4 _CKGEN.IEMA.NET69 _CKGEN.IEMA.I49.NDIN VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN8 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET057 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN9 _CKGEN.IEMA.I49.NET049 GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP0 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP1 _CKGEN.IEMA.NET69 _CKGEN.IEMA.I49.NDIN
+  _CKGEN.IEMA.I49.NET044 VNWP P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP2 _CKGEN.IEMA.I49.NET044 _CKGEN.IEMA.I49.NDIN VDDPE VNWP
+  P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXNA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=1.03U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXPA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN3 _CKGEN.IEMA.IRMUX._RDLY0.NET40
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET045 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN8 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET40 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN9 _CKGEN.IEMA.IRMUX._RDLY0.NET045
+  _CKGEN.IEMA.IRMUX.CKMX1O VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP0 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP2 _CKGEN.IEMA.IRMUX._RDLY0.NET030
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN _CKGEN.IEMA.IRMUX._RDLY0.NET030 VNWP
+  P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN3 _CKGEN.IEMA.IRMUX._RDLY1.NET046
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET038 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN8 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET046 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN9 _CKGEN.IEMA.IRMUX._RDLY1.NET038
+  _CKGEN.IEMA.IRMUX.CKDLY2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP0 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP2 _CKGEN.IEMA.IRMUX._RDLY1.NET030
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN _CKGEN.IEMA.IRMUX._RDLY1.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN3 _CKGEN.IEMA.IRMUX._RDLY2.NET046 SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET038 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN8 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET046 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN9 _CKGEN.IEMA.IRMUX._RDLY2.NET038 SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP0 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP2 _CKGEN.IEMA.IRMUX._RDLY2.NET030
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN _CKGEN.IEMA.IRMUX._RDLY2.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RMX0.I12.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I12.N1
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 EMA[0]
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A1 EMA[0] VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2
+  _CKGEN.IEMA.IRMUX._RMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNB1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.NCK_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA2 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPB1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP
+  _CKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VPW
+  N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXNA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.936U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXPA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXNA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXPA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen.Iema._wdly0.MXN3 _CKGEN.IEMA._WDLY0.NET057 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN4 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXN8 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN9 _CKGEN.IEMA._WDLY0.NET049 _CKGEN.IEMA.WCLK00 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXP0 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXP1 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN
+  _CKGEN.IEMA._WDLY0.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly0.MXP2 _CKGEN.IEMA._WDLY0.NET044 _CKGEN.IEMA._WDLY0.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXN3 _CKGEN.IEMA._WDLY1.NET057 _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN4 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXN8 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN9 _CKGEN.IEMA._WDLY1.NET049 _CKGEN.IEMA.DWCLK10 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXP0 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXP1 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN
+  _CKGEN.IEMA._WDLY1.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXP2 _CKGEN.IEMA._WDLY1.NET044 _CKGEN.IEMA._WDLY1.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXN3 _CKGEN.IEMA._WDLY2.NET057 _CKGEN.IEMA.NET69
+  _CKGEN.IEMA._WDLY2.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN4 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXN8 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET69
+  _CKGEN.IEMA._WDLY2.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN9 _CKGEN.IEMA._WDLY2.NET049 _CKGEN.IEMA.NET69 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXP0 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET69 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXP1 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN
+  _CKGEN.IEMA._WDLY2.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXP2 _CKGEN.IEMA._WDLY2.NET044 _CKGEN.IEMA._WDLY2.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA2 _CKGEN.IEMA._WMX0.I12.N1
+  _CKGEN.IEMA._WMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA2 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA._WMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01
+  _CKGEN.IEMA._WMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA2 _CKGEN.IEMA._WMX0.I13.N1 EMAW[0] VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA2 _CKGEN.IEMA._WMX0.A1 EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA2 _CKGEN.IEMA._WMX0.I18.A1A2 _CKGEN.IEMA._WMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNB1 _CKGEN.IEMA.WDLY _CKGEN.IEMA.NCK_IN VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA2 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A1
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPB1 _CKGEN.IEMA._WMX0.I18.A1A2UP _CKGEN.IEMA.NCK_IN
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXNA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXPA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXNA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET69 VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXPA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET69
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXNA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXPA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXNA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXPA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_IN VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_DLY VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXNA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXPA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen._memgtp.I1.MXNA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK
+  _CKGEN._MEMGTP.I1.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXNA2 _CKGEN._MEMGTP.I1.N1 RET1N VSSE VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXPA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXPA2 _CKGEN._MEMGTP.C1 RET1N VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I24.MXNA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNA2 _CKGEN._MEMGTP.I24.A1A2 _CKGEN._MEMGTP.NDFT VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNB1 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.C1 VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I24.MXPA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2UP
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPA2 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.NDFT
+  _CKGEN._MEMGTP.I24.A1A2UP VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPB1 _CKGEN._MEMGTP.I24.A1A2UP _CKGEN._MEMGTP.C1 VDDPE
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I6.MXNA1 GTP _CKGEN.NGTP VSSE VPW N11LL_CKT W=5.68U L=0.04U
X_M_ckgen._memgtp.I6.MXPA1 GTP _CKGEN.NGTP VDDPE VNWP P11LL_CKT W=11.37U
+  L=0.04U
X_M_ckgen._memgtp.I68.MXNA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen._memgtp.I68.MXPA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VDDPE VNWP
+  P11LL_CKT W=0.72U L=0.04U
X_M_ckgen._memgtp.I7.MXNA1 _CKGEN._MEMGTP.NCLK CLK VSS VPW N11LL_CKT W=4.26U
+  L=0.04U
X_M_ckgen._memgtp.I7.MXPA1 _CKGEN._MEMGTP.NCLK CLK VDDPE VNWP P11LL_CKT
+  W=4.26U L=0.04U
X_M_ckgen._memgtp.I74.MXNA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VSSE VPW
+  N11LL_CKT W=0.315U L=0.04U
X_M_ckgen._memgtp.I74.MXPA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen._memgtp.I82.MXNA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I82.MXPA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_M_ckgen._memgtp.I83.MXNA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2
+  _CKGEN._MEMGTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXNA2 _CKGEN._MEMGTP.I83.N1 _CKGEN.NET035 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXPA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I83.MXPA2 _CKGEN._MEMGTP.C3 _CKGEN.NET035 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I86.MXNA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I86.MXPA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.MXN0 _CKGEN._MEMGTP.NCLK _CKGEN._MEMGTP.CTR _CKGEN.NGTP VPW
+  N11LL_CKT W=4.25U L=0.04U
X_M_ckgen._memgtp.MXN7 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET114
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_ckgen._memgtp.MXN8 _CKGEN._MEMGTP.NET114 _CKGEN.RESET VSSE VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_ckgen._memgtp.MXP1 _CKGEN.NGTP _CKGEN.RESET VDDPE VNWP P11LL_CKT W=4.275U
+  L=0.04U
X_M_ckgen._memgtp.MXP2 _CKGEN._MEMGTP.NET127 _CKGEN._MEMGTP.CTR VDDPE VNWP
+  P11LL_CKT W=0.685U L=0.04U
X_M_ckgen._memgtp.MXP3 _CKGEN._MEMGTP.NET127 CLK VDDPE VNWP P11LL_CKT W=0.685U
+  L=0.04U
X_M_ckgen._memgtp.MXP5 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET127
+  VNWP P11LL_CKT W=0.685U L=0.04U
X_M_dftram_lat.I47.MXNA1 _DFTRAM_LAT.ND IDFTRAMBYP VSS VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_dftram_lat.I47.MXPA1 _DFTRAM_LAT.ND IDFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.68U L=0.04U
X_M_dftram_lat.I48.MXNOE DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.ND VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I48.MXPOEN DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.ND VNWP P11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I50.MXNA1 DFTRAMBYP_LAT DFT_LAT_NQ VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_dftram_lat.I50.MXPA1 DFTRAMBYP_LAT DFT_LAT_NQ VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_dftram_lat.I55.MXNA1 _DFTRAM_LAT.I55.N1 DFTRAMBYP_LAT VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXNOE DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPA1 _DFTRAM_LAT.I55.P1 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPOEN DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY _GWEN_LAT._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA2 _GWEN_LAT._ADDR_LAT.I0.N1 IDFTRAMBYP VSS VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA2 _GWEN_LAT._ADDR_LAT.NDY IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXNA1 GWEN_LAT_Q GWEN_LAT_NQ VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXPA1 GWEN_LAT_Q GWEN_LAT_NQ VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNA1 _GWEN_LAT._ADDR_LAT.I55.N1 GWEN_LAT_Q VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNOE GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPA1 _GWEN_LAT._ADDR_LAT.I55.P1 GWEN_LAT_Q VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPOEN GWEN_LAT_NQ NCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXNA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXPA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXNA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXPA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXNOE GWEN_LAT_NQ NCLK_GTPSA _GWEN_LAT._ADDR_LAT.ND
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXPOEN GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.ND VNWP P11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.MXN1 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN2 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.N1
+  VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN5 _GWEN_LAT._ADDR_LAT.N1 INTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN6 _GWEN_LAT._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXP1 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.P1
+  VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP3 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP4 _GWEN_LAT._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP5 _GWEN_LAT._ADDR_LAT.P2 INTE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_rdt_lat.I47.MXNA1 _RDT_LAT.ND RDT VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I47.MXPA1 _RDT_LAT.ND RDT VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_M_rdt_lat.I48.MXNOE NRDT_LAT NCLK _RDT_LAT.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I48.MXPOEN NRDT_LAT BCLK _RDT_LAT.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_rdt_lat.I50.MXNA1 RDT_P2 NRDT_LAT VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_rdt_lat.I50.MXPA1 RDT_P2 NRDT_LAT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_rdt_lat.I55.MXNA1 _RDT_LAT.I55.N1 RDT_P2 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_rdt_lat.I55.MXNOE NRDT_LAT BCLK _RDT_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPA1 _RDT_LAT.I55.P1 RDT_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPOEN NRDT_LAT NCLK _RDT_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I14.MXNA1 NWCLK _WRITE.NET0102 VSS VPW N11LL_CKT W=5.54U L=0.04U
X_M_write.I14.MXPA1 NWCLK _WRITE.NET0102 VDDPE VNWP P11LL_CKT W=5.67U L=0.04U
X_M_write.I27.MXNA1 _WRITE.NET0102 _WRITE.NET66 VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_write.I27.MXPA1 _WRITE.NET0102 _WRITE.NET66 VDDPE VNWP P11LL_CKT W=2.13U
+  L=0.04U
X_M_write.I52.MXNA1 INWCLK_WT BCLK _WRITE.I52.N2 VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXNA2 _WRITE.I52.N2 GWE_DFT _WRITE.I52.N1 VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXNA3 _WRITE.I52.N1 _WRITE.NET076 VSS VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXPA1 INWCLK_WT BCLK VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA2 INWCLK_WT GWE_DFT VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA3 INWCLK_WT _WRITE.NET076 VDDPE VNWP P11LL_CKT W=0.51U
+  L=0.04U
X_M_write.I53.MXNA1 _WRITE.NET66 GTP _WRITE.I53.NET39 VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXNA2 _WRITE.NET66 _WRITE.DGTP _WRITE.I53.NET39 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_write.I53.MXNB1 _WRITE.I53.NET39 GWE_DFT VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXPA1 _WRITE.NET66 GTP _WRITE.I53.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPA2 _WRITE.I53.P1 _WRITE.DGTP VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPB1 _WRITE.NET66 GWE_DFT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_write.I61.MXNA1 _WRITE.NET035 WR_THRU VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_write.I61.MXNA2 _WRITE.NET035 DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I61.MXPA1 _WRITE.NET035 WR_THRU _WRITE.I61.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I61.MXPA2 _WRITE.I61.P1 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I62.MXNA1 _WRITE.NET076 _WRITE.NET035 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I62.MXPA1 _WRITE.NET076 _WRITE.NET035 VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I64.MXNA1 GWE_DFT NGWE_DFT VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_write.I64.MXPA1 GWE_DFT NGWE_DFT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_write.MXN0 WRITE_NGTP DLY_DWL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN3 _WRITE.NET037 WRITE_NGTP VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN8 _WRITE.DGTP WRITE_NGTP _WRITE.NET037 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_write.MXP0 _WRITE.DGTP WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP1 VDDPE DLY_DWL VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP2 WRITE_NGTP DLY_DWL VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ydec.I10_0.MXNA1 _YDEC.YSEL[0] CADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_0.MXNA2 _YDEC.YSEL[0] CADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_0.MXPA1 _YDEC.YSEL[0] CADDR1 _YDEC.I10_0.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_0.MXPA2 _YDEC.I10_0.P1 CADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_1.MXNA1 _YDEC.YSEL[1] CADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_1.MXNA2 _YDEC.YSEL[1] NCADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_1.MXPA1 _YDEC.YSEL[1] CADDR1 _YDEC.I10_1.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_1.MXPA2 _YDEC.I10_1.P1 NCADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_2.MXNA1 _YDEC.YSEL[2] NCADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_2.MXNA2 _YDEC.YSEL[2] CADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_2.MXPA1 _YDEC.YSEL[2] NCADDR1 _YDEC.I10_2.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_2.MXPA2 _YDEC.I10_2.P1 CADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_3.MXNA1 _YDEC.YSEL[3] NCADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_3.MXNA2 _YDEC.YSEL[3] NCADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_3.MXPA1 _YDEC.YSEL[3] NCADDR1 _YDEC.I10_3.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_3.MXPA2 _YDEC.I10_3.P1 NCADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA1 _YDEC.NGTP_DFT GTP _YDEC.I13.N1 VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA2 _YDEC.I13.N1 NDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXPA1 _YDEC.NGTP_DFT GTP VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_M_ydec.I13.MXPA2 _YDEC.NGTP_DFT NDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA1 _YDEC.CLK_WR _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA2 _YDEC.CLK_WR NGWE VSSE VPW N11LL_CKT W=0.71U L=0.04U
X_M_ydec.I7.MXPA1 _YDEC.CLK_WR _YDEC.NGTP_DFT _YDEC.I7.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I7.MXPA2 _YDEC.I7.P1 NGWE VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I8.MXNA1 _YDEC.CLK_RD _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_ydec.I8.MXNA2 _YDEC.CLK_RD GWE_P2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ydec.I8.MXPA1 _YDEC.CLK_RD _YDEC.NGTP_DFT _YDEC.I8.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I8.MXPA2 _YDEC.I8.P1 GWE_P2 VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I9.MXNA1 NGWE GWE_P2 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ydec.I9.MXPA1 NGWE GWE_P2 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ydec._rmux_0.I39.MXNA1 NYR0 _YDEC._RMUX_0.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_0.I39.MXPA1 NYR0 _YDEC._RMUX_0.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_0.MXN0 _YDEC._RMUX_0.INYP _YDEC.YSEL[0] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_0.MXN1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_0.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_0.MXP0 _YDEC._RMUX_0.INYP _YDEC.YSEL[0] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_0.MXP1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_0.MXP2 _YDEC._RMUX_0.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.I39.MXNA1 NYR1 _YDEC._RMUX_1.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_1.I39.MXPA1 NYR1 _YDEC._RMUX_1.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_1.MXN0 _YDEC._RMUX_1.INYP _YDEC.YSEL[1] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_1.MXN1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_1.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_1.MXP0 _YDEC._RMUX_1.INYP _YDEC.YSEL[1] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.MXP1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_1.MXP2 _YDEC._RMUX_1.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_2.I39.MXNA1 NYR2 _YDEC._RMUX_2.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_2.I39.MXPA1 NYR2 _YDEC._RMUX_2.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_2.MXN0 _YDEC._RMUX_2.INYP _YDEC.YSEL[2] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_2.MXN1 _YDEC._RMUX_2.IYP _YDEC._RMUX_2.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_2.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_2.MXP0 _YDEC._RMUX_2.INYP _YDEC.YSEL[2] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_2.MXP1 _YDEC._RMUX_2.IYP _YDEC._RMUX_2.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_2.MXP2 _YDEC._RMUX_2.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_3.I39.MXNA1 NYR3 _YDEC._RMUX_3.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_3.I39.MXPA1 NYR3 _YDEC._RMUX_3.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_3.MXN0 _YDEC._RMUX_3.INYP _YDEC.YSEL[3] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_3.MXN1 _YDEC._RMUX_3.IYP _YDEC._RMUX_3.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_3.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_3.MXP0 _YDEC._RMUX_3.INYP _YDEC.YSEL[3] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_3.MXP1 _YDEC._RMUX_3.IYP _YDEC._RMUX_3.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_3.MXP2 _YDEC._RMUX_3.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._wmux_0.MXN0 _YDEC._WMUX_0.INYP _YDEC.YSEL[0] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_0.MXN1 YW0 _YDEC._WMUX_0.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_0.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_0.MXP0 _YDEC._WMUX_0.INYP _YDEC.YSEL[0] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_0.MXP1 YW0 _YDEC._WMUX_0.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_0.MXP2 _YDEC._WMUX_0.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_1.MXN0 _YDEC._WMUX_1.INYP _YDEC.YSEL[1] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_1.MXN1 YW1 _YDEC._WMUX_1.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_1.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_1.MXP0 _YDEC._WMUX_1.INYP _YDEC.YSEL[1] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_1.MXP1 YW1 _YDEC._WMUX_1.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_1.MXP2 _YDEC._WMUX_1.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_2.MXN0 _YDEC._WMUX_2.INYP _YDEC.YSEL[2] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_2.MXN1 YW2 _YDEC._WMUX_2.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_2.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_2.MXP0 _YDEC._WMUX_2.INYP _YDEC.YSEL[2] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_2.MXP1 YW2 _YDEC._WMUX_2.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_2.MXP2 _YDEC._WMUX_2.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_3.MXN0 _YDEC._WMUX_3.INYP _YDEC.YSEL[3] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_3.MXN1 YW3 _YDEC._WMUX_3.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_3.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_3.MXP0 _YDEC._WMUX_3.INYP _YDEC.YSEL[3] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_3.MXP1 YW3 _YDEC._WMUX_3.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_3.MXP2 _YDEC._WMUX_3.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
.ENDS RAMSP4096X16CKM8_BIST
****
.SUBCKT RAMSP4096X16CNTRL ACTP ADDR BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1
+  CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAM_RET DUMMY_DWL_L DUMMY_DWL_R
+  DUM_NWCLK DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL
+  EMAW[0] EMAW[1] EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4
+  FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN
+  GWENY IDFTRAMBYP LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_WT
+  NYR0 NYR1 NYR2 NYR3 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RET RET1N SAE_DUMMY
+  SAPRECH SEL_D SEL_SI SEL_TD SO0 SO1 TE TWEN VDDCE VDDC_LEFT VDDC_RIGHT VDDP
+  VDDPE VPW WEN YW0 YW1 YW2 YW3
** RAMSP4096X16CNTRL: 831 flat devices **
XCK ACTP ADDR BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DBL LOG0 DFTRAM_RET DUMMY_DWL_L DUMMY_DWL_R LOG0 DUM_NWCLK DUM_PEN
+  DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL DWL EMAW[0] EMAW[1]
+  EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6
+  FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP
+  LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1
+  NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0]
+  RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] LOG0 RET RET1N SAE_DUMMY
+  SAPRECH LOG0 SEL_D SEL_SI SEL_TD SO0 SO1 LOG0 LOG0 LOG0 LOG0 TE LOG1 LOG0
+  LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 TWEN VDDCE VDDCE VDDC_LEFT
+  VDDCE VDDC_RIGHT VDDP VDDPE VDDPE VDDCE VDDPE VPW VPW VPW WEN LOG0 YW0 YW1
+  YW2 YW3 RAMSP4096X16CKM8_BIST
.ENDS RAMSP4096X16CNTRL
****
.SUBCKT RAMSP4096X16IOCDM_R ADDR BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL2_0 BL2_1 BL2_2
+  BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7 BL5_0 BL5_1 BL5_2
+  BL5_3 BL5_4 BL5_5 BL5_6 BL5_7 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6
+  BL6_7 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7 BLPRECH DFTRAMBYP DWL
+  D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4
+  IADDR_5 IADDR_6 IADDR_7 IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3
+  IADDR_NSAE_4 IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 LOG0 NACT_CC NADDR_0
+  NADDR_1 NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0
+  NADDR_NSAE_1 NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5
+  NADDR_NSAE_6 NADDR_NSAE_7 NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL0_4 NBL0_5 NBL0_6
+  NBL0_7 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4 NBL1_5 NBL1_6 NBL1_7 NBL2_0
+  NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6 NBL2_7 NBL3_0 NBL3_1 NBL3_2
+  NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7 NBL4_0 NBL4_1 NBL4_2 NBL4_3 NBL4_4
+  NBL4_5 NBL4_6 NBL4_7 NBL5_0 NBL5_1 NBL5_2 NBL5_3 NBL5_4 NBL5_5 NBL5_6
+  NBL5_7 NBL6_0 NBL6_1 NBL6_2 NBL6_3 NBL6_4 NBL6_5 NBL6_6 NBL6_7 NBL7_0
+  NBL7_1 NBL7_2 NBL7_3 NBL7_4 NBL7_5 NBL7_6 NBL7_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1
+  SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD SI SO TD_0
+  TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2
+  TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4
+  VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6
+  VNWC_7 VPW WENL WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
** RAMSP4096X16IOCDM_R: 1912 flat devices **
XR_IO_I1 ADDR BL0_1 BL1_1 BL2_1 BL3_1 BL4_1 BL5_1 BL6_1 BL7_1 BLPRECH D_1
+  DFTRAMBYP DWL IADDR_1 IADDR_NSAE_1 LOG0 NACT_CC NADDR_1 NADDR_NSAE_1 NBL0_1
+  NBL1_1 NBL2_1 NBL3_1 NBL4_1 NBL5_1 NBL6_1 NBL7_1 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_1 SAO_1 SAPRECH SEL_D SEL_SI SEL_TD SI_6 SO_0 TD_1 TE
+  TWEN_1 TWENL_8 TWENR_2 TWEN_1 VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW
+  WEN_1 WENL_10 WENR_4 WENY_1 WEN_1 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
XR_IO_I2 ADDR BL0_2 BL1_2 BL2_2 BL3_2 BL4_2 BL5_2 BL6_2 BL7_2 BLPRECH D_2
+  DFTRAMBYP DWL IADDR_2 IADDR_NSAE_2 LOG0 NACT_CC NADDR_2 NADDR_NSAE_2 NBL0_2
+  NBL1_2 NBL2_2 NBL3_2 NBL4_2 NBL5_2 NBL6_2 NBL7_2 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_2 SAO_2 SAPRECH SEL_D SEL_SI SEL_TD SI_12 SI_6 TD_2 TE
+  TWEN_2 TWENL_14 TWENL_8 TWEN_2 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW
+  WEN_2 WENL_16 WENL_10 WENY_2 WEN_2 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XR_IO_I3 ADDR BL0_3 BL1_3 BL2_3 BL3_3 BL4_3 BL5_3 BL6_3 BL7_3 BLPRECH D_3
+  DFTRAMBYP DWL IADDR_3 IADDR_NSAE_3 LOG0 NACT_CC NADDR_3 NADDR_NSAE_3 NBL0_3
+  NBL1_3 NBL2_3 NBL3_3 NBL4_3 NBL5_3 NBL6_3 NBL7_3 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_3 SAO_3 SAPRECH SEL_D SEL_SI SEL_TD SI_18 SI_12 TD_3 TE
+  TWEN_3 TWENL_20 TWENL_14 TWEN_3 VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW
+  WEN_3 WENL_22 WENL_16 WENY_3 WEN_3 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XR_IO_I4 ADDR BL0_4 BL1_4 BL2_4 BL3_4 BL4_4 BL5_4 BL6_4 BL7_4 BLPRECH D_4
+  DFTRAMBYP DWL IADDR_4 IADDR_NSAE_4 LOG0 NACT_CC NADDR_4 NADDR_NSAE_4 NBL0_4
+  NBL1_4 NBL2_4 NBL3_4 NBL4_4 NBL5_4 NBL6_4 NBL7_4 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_4 SAO_4 SAPRECH SEL_D SEL_SI SEL_TD SI_24 SI_18 TD_4 TE
+  TWEN_4 TWENL_26 TWENL_20 TWEN_4 VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW
+  WEN_4 WENL_28 WENL_22 WENY_4 WEN_4 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XR_IO_I5 ADDR BL0_5 BL1_5 BL2_5 BL3_5 BL4_5 BL5_5 BL6_5 BL7_5 BLPRECH D_5
+  DFTRAMBYP DWL IADDR_5 IADDR_NSAE_5 LOG0 NACT_CC NADDR_5 NADDR_NSAE_5 NBL0_5
+  NBL1_5 NBL2_5 NBL3_5 NBL4_5 NBL5_5 NBL6_5 NBL7_5 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_5 SAO_5 SAPRECH SEL_D SEL_SI SEL_TD SI_30 SI_24 TD_5 TE
+  TWEN_5 TWENL_32 TWENL_26 TWEN_5 VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW
+  WEN_5 WENL_34 WENL_28 WENY_5 WEN_5 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XR_IO_I6 ADDR BL0_6 BL1_6 BL2_6 BL3_6 BL4_6 BL5_6 BL6_6 BL7_6 BLPRECH D_6
+  DFTRAMBYP DWL IADDR_6 IADDR_NSAE_6 LOG0 NACT_CC NADDR_6 NADDR_NSAE_6 NBL0_6
+  NBL1_6 NBL2_6 NBL3_6 NBL4_6 NBL5_6 NBL6_6 NBL7_6 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_6 SAO_6 SAPRECH SEL_D SEL_SI SEL_TD SI_36 SI_30 TD_6 TE
+  TWEN_6 TWENL_38 TWENL_32 TWEN_6 VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW
+  WEN_6 WENL_40 WENL_34 WENY_6 WEN_6 YW0 YW1 YW2 YW3
+  RAMSP4096X16COLM8_BIST_WM
XR_IO_L ADDR BL0_0 BL1_0 BL2_0 BL3_0 BL4_0 BL5_0 BL6_0 BL7_0 BLPRECH D_0
+  DFTRAMBYP DWL IADDR_0 IADDR_NSAE_0 LOG0 NACT_CC NADDR_0 NADDR_NSAE_0 NBL0_0
+  NBL1_0 NBL2_0 NBL3_0 NBL4_0 NBL5_0 NBL6_0 NBL7_0 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_0 SAO_0 SAPRECH SEL_D SEL_SI SEL_TD SO_0 SO TD_0 TE
+  TWEN_0 TWENR_2 TWENR TWEN_0 VDDC_0 VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW
+  WEN_0 WENR_4 WENR WENY_0 WEN_0 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
XR_IO_R ADDR BL0_7 BL1_7 BL2_7 BL3_7 BL4_7 BL5_7 BL6_7 BL7_7 BLPRECH D_7
+  DFTRAMBYP DWL IADDR_7 IADDR_NSAE_7 LOG0 NACT_CC NADDR_7 NADDR_NSAE_7 NBL0_7
+  NBL1_7 NBL2_7 NBL3_7 NBL4_7 NBL5_7 NBL6_7 NBL7_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAE_7 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD SI SI_36 TD_7 TE
+  TWEN_7 TWENL TWENL_38 TWEN_7 VDDC_7 VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW
+  WEN_7 WENL WENL_40 WENY_7 WEN_7 YW0 YW1 YW2 YW3 RAMSP4096X16COLM8_BIST_WM
.ENDS RAMSP4096X16IOCDM_R
****
.SUBCKT RAMSP4096X16IO_RDM_R DWL_L DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7
+  IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7
+  IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4
+  IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 NADDR_0 NADDR_1 NADDR_2 NADDR_3
+  NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1 NADDR_NSAE_2
+  NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5 NADDR_NSAE_6 NADDR_NSAE_7 Q_0 Q_1
+  Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7
+  SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0 VNWP_1
+  VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3
+  WEN_4 WEN_5 WEN_6 WEN_7
** RAMSP4096X16IO_RDM_R: 96 flat devices **
XR_RDM_1 D_1 DWL_R_0 DWL_R_2 IADDR_1 IADDR_NSAE_1 NADDR_1 NADDR_NSAE_1 Q_1
+  SAE_1 SAO_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1 VNWP_1 VPW_1 VSS_1 VSS_1 WEN_1
+  WENY_1 RAMSP4096X16RDM8
XR_RDM_2 D_2 DWL_R_2 DWL_R_6 IADDR_2 IADDR_NSAE_2 NADDR_2 NADDR_NSAE_2 Q_2
+  SAE_2 SAO_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2 VNWP_2 VPW_2 VSS_2 VSS_2 WEN_2
+  WENY_2 RAMSP4096X16RDM8
XR_RDM_3 D_3 DWL_R_6 DWL_R_8 IADDR_3 IADDR_NSAE_3 NADDR_3 NADDR_NSAE_3 Q_3
+  SAE_3 SAO_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3 VSS_3 VSS_3 WEN_3
+  WENY_3 RAMSP4096X16RDM8
XR_RDM_4 D_4 DWL_R_8 DWL_R_10 IADDR_4 IADDR_NSAE_4 NADDR_4 NADDR_NSAE_4 Q_4
+  SAE_4 SAO_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4 VNWP_4 VPW_4 VSS_4 VSS_4 WEN_4
+  WENY_4 RAMSP4096X16RDM8
XR_RDM_5 D_5 DWL_R_10 DWL_R_12 IADDR_5 IADDR_NSAE_5 NADDR_5 NADDR_NSAE_5 Q_5
+  SAE_5 SAO_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5 VNWP_5 VPW_5 VSS_5 VSS_5 WEN_5
+  WENY_5 RAMSP4096X16RDM8
XR_RDM_6 D_6 DWL_R_12 DWL_L_4 IADDR_6 IADDR_NSAE_6 NADDR_6 NADDR_NSAE_6 Q_6
+  SAE_6 SAO_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6 VNWP_6 VPW_6 VSS_6 VSS_6 WEN_6
+  WENY_6 RAMSP4096X16RDM8
XR_RDM_L D_0 DWL_L DWL_R_0 IADDR_0 IADDR_NSAE_0 NADDR_0 NADDR_NSAE_0 Q_0 SAE_0
+  SAO_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0 VSS_0 VSS_0 WEN_0 WENY_0
+  RAMSP4096X16RDM8
XR_RDM_R D_7 DWL_L_4 DWL_R IADDR_7 IADDR_NSAE_7 NADDR_7 NADDR_NSAE_7 Q_7 SAE_7
+  SAO_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7 VNWP_7 VPW_7 VSS_7 VSS_7 WEN_7 WENY_7
+  RAMSP4096X16RDM8
.ENDS RAMSP4096X16IO_RDM_R
****
.SUBCKT RAMSP4096X16IOTOPCAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VPW
** RAMSP4096X16IOTOPCAP_R: 512 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VPW VPW
+  RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
XIOTOPCAP_L9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VPW VPW RAMSP4096X16CCHD4_TOPBOT
.ENDS RAMSP4096X16IOTOPCAP_R
****
.SUBCKT RAMSP4096X16IO_ROW_R ADDR BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3
+  BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12
+  BL[0]_13 BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14
+  BL[2]_15 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  DFTRAMBYP DWL DWL_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0_0 LOG0_1 NACT_CC
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14
+  NBL[0]_15 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SO TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6
+  TWEN_7 VDDC VDDPE VPW WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
** RAMSP4096X16IO_ROW_R: 2523 flat devices **
XIO_CDM_ROW_R ADDR BL[0]_0 BL[0]_2 BL[0]_4 BL[0]_6 BL[0]_8 BL[0]_10 BL[0]_12
+  BL[0]_14 BL[1]_0 BL[1]_2 BL[1]_4 BL[1]_6 BL[1]_8 BL[1]_10 BL[1]_12 BL[1]_14
+  BL[2]_0 BL[2]_2 BL[2]_4 BL[2]_6 BL[2]_8 BL[2]_10 BL[2]_12 BL[2]_14 BL[3]_0
+  BL[3]_2 BL[3]_4 BL[3]_6 BL[3]_8 BL[3]_10 BL[3]_12 BL[3]_14 BL[0]_1 BL[0]_3
+  BL[0]_5 BL[0]_7 BL[0]_9 BL[0]_11 BL[0]_13 BL[0]_15 BL[1]_1 BL[1]_3 BL[1]_5
+  BL[1]_7 BL[1]_9 BL[1]_11 BL[1]_13 BL[1]_15 BL[2]_1 BL[2]_3 BL[2]_5 BL[2]_7
+  BL[2]_9 BL[2]_11 BL[2]_13 BL[2]_15 BL[3]_1 BL[3]_3 BL[3]_5 BL[3]_7 BL[3]_9
+  BL[3]_11 BL[3]_13 BL[3]_15 BLPRECH DFTRAMBYP DWL D_0 D_1 D_2 D_3 D_4 D_5
+  D_6 D_7 IADDR_0 IADDR_1 IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7
+  IADDR_NSAE_0 IADDR_NSAE_1 IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4
+  IADDR_NSAE_5 IADDR_NSAE_6 IADDR_NSAE_7 LOG0_1 NACT_CC NADDR_0 NADDR_1
+  NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6 NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1
+  NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4 NADDR_NSAE_5 NADDR_NSAE_6
+  NADDR_NSAE_7 NBL[0]_0 NBL[0]_2 NBL[0]_4 NBL[0]_6 NBL[0]_8 NBL[0]_10
+  NBL[0]_12 NBL[0]_14 NBL[1]_0 NBL[1]_2 NBL[1]_4 NBL[1]_6 NBL[1]_8 NBL[1]_10
+  NBL[1]_12 NBL[1]_14 NBL[2]_0 NBL[2]_2 NBL[2]_4 NBL[2]_6 NBL[2]_8 NBL[2]_10
+  NBL[2]_12 NBL[2]_14 NBL[3]_0 NBL[3]_2 NBL[3]_4 NBL[3]_6 NBL[3]_8 NBL[3]_10
+  NBL[3]_12 NBL[3]_14 NBL[0]_1 NBL[0]_3 NBL[0]_5 NBL[0]_7 NBL[0]_9 NBL[0]_11
+  NBL[0]_13 NBL[0]_15 NBL[1]_1 NBL[1]_3 NBL[1]_5 NBL[1]_7 NBL[1]_9 NBL[1]_11
+  NBL[1]_13 NBL[1]_15 NBL[2]_1 NBL[2]_3 NBL[2]_5 NBL[2]_7 NBL[2]_9 NBL[2]_11
+  NBL[2]_13 NBL[2]_15 NBL[3]_1 NBL[3]_3 NBL[3]_5 NBL[3]_7 NBL[3]_9 NBL[3]_11
+  NBL[3]_13 NBL[3]_15 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAE_0 SAE_1
+  SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5
+  SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 SO TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VPW WENL WENR WENY_0 WENY_1 WENY_2 WENY_3
+  WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  YW0 YW1 YW2 YW3 RAMSP4096X16IOCDM_R
XIO_EDGE_R ADDR BLPRECH DFTRAMBYP DWL LOG0_1 NACT_CC NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL VDDC VDDC VDDPE
+  VDDC VPW VPW WENL YW0 YW1 YW2 YW3 RAMSP4096X16IOEDGE
XIO_RDM_ROW_R DWL_L DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 IADDR_0 IADDR_1
+  IADDR_2 IADDR_3 IADDR_4 IADDR_5 IADDR_6 IADDR_7 IADDR_NSAE_0 IADDR_NSAE_1
+  IADDR_NSAE_2 IADDR_NSAE_3 IADDR_NSAE_4 IADDR_NSAE_5 IADDR_NSAE_6
+  IADDR_NSAE_7 NADDR_0 NADDR_1 NADDR_2 NADDR_3 NADDR_4 NADDR_5 NADDR_6
+  NADDR_7 NADDR_NSAE_0 NADDR_NSAE_1 NADDR_NSAE_2 NADDR_NSAE_3 NADDR_NSAE_4
+  NADDR_NSAE_5 NADDR_NSAE_6 NADDR_NSAE_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  SAE_0 SAE_1 SAE_2 SAE_3 SAE_4 SAE_5 SAE_6 SAE_7 SAO_0 SAO_1 SAO_2 SAO_3
+  SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0
+  TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMSP4096X16IO_RDM_R
XIO_TOPCAP_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9
+  BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8
+  NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14
+  NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDC VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW RAMSP4096X16IOTOPCAP_R
.ENDS RAMSP4096X16IO_ROW_R
****
.SUBCKT RAMSP4096X16IO_SLICE ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22
+  BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30
+  BL[1]_31 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 BL[3]_16
+  BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23 BL[3]_24
+  BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31 CA0 CA1 CA2
+  CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAM_RET DUM_NWCLK DUM_PEN
+  DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL_WDX D_0 D_1 D_2 D_3 D_4
+  D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMAW[0] EMAW[1] EMA[0]
+  EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY LA0 LA1 LA2 LAY0
+  LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_1 LOG0_2 LOG0_DWL LOG1
+  NACTC NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5
+  NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11
+  NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18
+  NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25
+  NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22
+  NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29
+  NBL[2]_30 NBL[2]_31 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NGWE NRETNVT Q_0 Q_1 Q_2 Q_3 Q_4
+  Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5
+  RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4]
+  RA_P2[5] RET RET1N SAE_DUMMY SEL_D SEL_SI SEL_TD SO0 SO1 TD_0 TD_1 TD_2
+  TD_3 TD_4 TD_5 TD_6 TD_7 TD_8 TD_9 TD_10 TD_11 TD_12 TD_13 TD_14 TD_15
+  TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 TWEN_8 TWEN_9
+  TWEN_10 TWEN_11 TWEN_12 TWEN_13 TWEN_14 TWEN_15 VDDC VDDP VDDPE VPW WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10
+  WENY_11 WENY_12 WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMSP4096X16IO_SLICE: 5877 flat devices **
XCK_BLK ACTP ADDR BLPRECH BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK
+  CRE1 CRE2 DBL DFTRAM_RET DWL_L DUMMY_DWL_R DUM_NWCLK DUM_PEN DUM_PENSI
+  DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL_WDX EMAW[0] EMAW[1] EMA[0] EMA[1]
+  EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY DFTRAMBYP LA0 LA1 LA2
+  LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_DWL LOG1 NACTC
+  NACT_CC NGWE NRETNVT NSAE SO NSAO_R NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 RA0
+  RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1]
+  RA_P2[2] RA_P2[3] RA_P2[4] RA_P2[5] RET RET1N SAE_DUMMY SAPRECH SEL_D
+  SEL_SI SEL_TD SO0 SO1 TE TWENR VDDC VDDC VDDC VDDP VDDPE VPW WENR YW0 YW1
+  YW2 YW3 RAMSP4096X16CNTRL
XIO_LEFT ADDR BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9
+  BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 DFTRAMBYP LOG0_0
+  DWL_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0_1 LOG0_0 NACT_CC NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SO TD_0 TD_1 TD_2 TD_3 TD_4
+  TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6
+  TWEN_7 VDDC VDDPE VPW WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
+  RAMSP4096X16IO_ROW_L
XIO_RIGHT ADDR BLPRECH_R BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21
+  BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29
+  BL[2]_30 BL[2]_31 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 DFTRAMBYP DWL_WDX DUMMY_DWL_R D_8 D_9 D_10 D_11 D_12 D_13
+  D_14 D_15 LOG0_2 LOG0_0 NACT_CC NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19
+  NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26
+  NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[1]_16 NBL[1]_17
+  NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24
+  NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31
+  NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22
+  NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29
+  NBL[2]_30 NBL[2]_31 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 SAPRECH SEL_D SEL_SI SEL_TD
+  NSAO_R TD_8 TD_9 TD_10 TD_11 TD_12 TD_13 TD_14 TD_15 TE TWENR TWEN_8 TWEN_9
+  TWEN_10 TWEN_11 TWEN_12 TWEN_13 TWEN_14 TWEN_15 VDDC VDDPE VPW WENR WENY_8
+  WENY_9 WENY_10 WENY_11 WENY_12 WENY_13 WENY_14 WENY_15 WEN_8 WEN_9 WEN_10
+  WEN_11 WEN_12 WEN_13 WEN_14 WEN_15 YW0 YW1 YW2 YW3 RAMSP4096X16IO_ROW_R
.ENDS RAMSP4096X16IO_SLICE
****
.SUBCKT RAMSP4096X16CCHD4_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP4096X16CCHD4_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4_EDG
****
.SUBCKT RAMSP4096X16CCHD4WD_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP4096X16CCHD4WD_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4WD_EDG
****
.SUBCKT RAMSP4096X16CCHD4 BL[0] BL[1] BL[2] BL[3] CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0] NBL[1] NBL[2] NBL[3]
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC VDDCE VDDPE VNWC VPW VSSE WL[0] WL[1]
** RAMSP4096X16CCHD4: 48 flat devices **
X_MI17._cell.MXN0 NCORED30 CORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXN1 NBL[3] WL[0] NCORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN2 BL[3] WL[0] CORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN3 CORED30 NCORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXP0 NCORED30 CORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI17._cell.MXP1 CORED30 NCORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXN0 NCORED20 CORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXN1 NBL[2] WL[0] NCORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN2 BL[2] WL[0] CORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN3 CORED20 NCORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXP0 NCORED20 CORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXP1 CORED20 NCORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXN0 NCORED10 CORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXN1 NBL[1] WL[0] NCORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN2 BL[1] WL[0] CORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN3 CORED10 NCORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXP0 NCORED10 CORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXP1 CORED10 NCORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXN0 NCORED00 CORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXN1 NBL[0] WL[0] NCORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN2 BL[0] WL[0] CORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN3 CORED00 NCORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXP0 NCORED00 CORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXP1 CORED00 NCORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_M_cell01._cell.MXN0 NCORED01 CORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXN1 NBL[0] WL[1] NCORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN2 BL[0] WL[1] CORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN3 CORED01 NCORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXP0 NCORED01 CORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell01._cell.MXP1 CORED01 NCORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXN0 NCORED11 CORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXN1 NBL[1] WL[1] NCORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN2 BL[1] WL[1] CORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN3 CORED11 NCORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXP0 NCORED11 CORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXP1 CORED11 NCORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXN0 NCORED21 CORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXN1 NBL[2] WL[1] NCORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN2 BL[2] WL[1] CORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN3 CORED21 NCORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXP0 NCORED21 CORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXP1 CORED21 NCORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXN0 NCORED31 CORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXN1 NBL[3] WL[1] NCORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN2 BL[3] WL[1] CORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN3 CORED31 NCORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXP0 NCORED31 CORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXP1 CORED31 NCORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
.ENDS RAMSP4096X16CCHD4
****
.SUBCKT RAMSP4096X16MEM_L_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_ROW: 772 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_384 NCORED01_386
+  NCORED10_388 NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396
+  NCORED31_398 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_416 NCORED01_418
+  NCORED10_420 NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428
+  NCORED31_430 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_256 NCORED01_258 NCORED10_260
+  NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268 NCORED31_270 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_288 NCORED01_290 NCORED10_292
+  NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300 NCORED31_302 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
.ENDS RAMSP4096X16MEM_L_ROW
****
.SUBCKT RAMSP4096X16MEM_L_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_MIDT_ROW: 772 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_384 NCORED01_386
+  NCORED10_388 NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396
+  NCORED31_398 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_416 NCORED01_418
+  NCORED10_420 NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428
+  NCORED31_430 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_256 NCORED01_258 NCORED10_260
+  NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268 NCORED31_270 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_288 NCORED01_290 NCORED10_292
+  NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300 NCORED31_302 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
.ENDS RAMSP4096X16MEM_L_MIDT_ROW
****
.SUBCKT RAMSP4096X16CCHD4_EDG_STRAP VNWC VNWP VPW VSSE
** RAMSP4096X16CCHD4_EDG_STRAP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4_EDG_STRAP
****
.SUBCKT RAMSP4096X16CCHD4WD_EDG_STRP VNWC VNWP VPW VSSE
** RAMSP4096X16CCHD4WD_EDG_STRP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4WD_EDG_STRP
****
.SUBCKT RAMSP4096X16CCHD4_STRAP BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** RAMSP4096X16CCHD4_STRAP: 24 flat devices **
X_MXN36 VSSE NET96 NET107 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN37 VSSE NET76 NET139 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN38 NBL[2] VPW NET135 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN39 NBL[3] VPW NET159 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN40 NET130 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN41 NBL[2] VPW NET127 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN42 VSSE NET100 NET151 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN43 VSSE NET92 NET123 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN44 VSSE NET88 NET163 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN45 VSSE NET72 NET115 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN46 NBL[0] VPW NET155 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN47 NET118 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN48 NBL[1] VPW NET143 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN49 NBL[0] VPW NET111 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN50 VSSE NET84 NET103 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN51 VSSE NET80 NET147 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET95 NET96 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 NET75 NET76 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 NET99 NET100 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 VDDC NET92 NET89 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 VDDC NET88 NET85 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 NET71 NET72 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP18 NET83 NET84 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP19 NET79 NET80 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMSP4096X16CCHD4_STRAP
****
.SUBCKT RAMSP4096X16MEM_L_STRAPROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7
+  VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC VNWP_0 VNWP_1
+  VPW
** RAMSP4096X16MEM_L_STRAPROW: 388 flat devices **
XMEM_STRAP0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC_0 VNWC VDDPE_0 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC_1 VNWC VDDPE_1 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10 NBL[2]_10
+  NBL[3]_10 VDDC_10 VNWC VDDPE_10 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11 NBL[2]_11
+  NBL[3]_11 VDDC_11 VNWC VDDPE_11 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12 NBL[2]_12
+  NBL[3]_12 VDDC_12 VNWC VDDPE_12 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13 NBL[2]_13
+  NBL[3]_13 VDDC_13 VNWC VDDPE_13 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14 NBL[2]_14
+  NBL[3]_14 VDDC_14 VNWC VDDPE_14 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15 NBL[2]_15
+  NBL[3]_15 VDDC_15 VNWC VDDPE_15 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC_2 VNWC VDDPE_2 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC_3 VNWC VDDPE_3 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC_4 VNWC VDDPE_4 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC_5 VNWC VDDPE_5 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC_6 VNWC VDDPE_6 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC_7 VNWC VDDPE_7 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC_8 VNWC VDDPE_8 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAP9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC_9 VNWC VDDPE_9 VNWC VPW VPW RAMSP4096X16CCHD4_STRAP
XMEM_STRAPEDGEL VNWC VNWP_0 VPW VPW RAMSP4096X16CCHD4_EDG_STRAP
XMEM_STRAPEDGER VNWC VNWP_1 VPW VPW RAMSP4096X16CCHD4WD_EDG_STRP
.ENDS RAMSP4096X16MEM_L_STRAPROW
****
.SUBCKT RAMSP4096X16MEM_L_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_MID_ROW: 772 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_384 NCORED01_386
+  NCORED10_388 NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396
+  NCORED31_398 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_416 NCORED01_418
+  NCORED10_420 NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428
+  NCORED31_430 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_256 NCORED01_258 NCORED10_260
+  NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268 NCORED31_270 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_288 NCORED01_290 NCORED10_292
+  NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300 NCORED31_302 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
.ENDS RAMSP4096X16MEM_L_MID_ROW
****
.SUBCKT RAMSP4096X16MEM_L_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_BOT_ROW: 772 flat devices **
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_384 NCORED01_386
+  NCORED10_388 NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396
+  NCORED31_398 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_416 NCORED01_418
+  NCORED10_420 NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428
+  NCORED31_430 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_2 VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_4 NBL[1]_4
+  NBL[2]_4 NBL[3]_4 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_4 VDDCE_4 VDDPE_4
+  VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_5 NBL[1]_5
+  NBL[2]_5 NBL[3]_5 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_5 VDDCE_5 VDDPE_5
+  VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_BOT_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_256 NCORED01_258 NCORED10_260
+  NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268 NCORED31_270 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_BOT_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_288 NCORED01_290 NCORED10_292
+  NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300 NCORED31_302 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_BOT_R0 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_BOT_R1 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
.ENDS RAMSP4096X16MEM_L_BOT_ROW
****
.SUBCKT RAMSP4096X16CCHD4WD_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP4096X16CCHD4WD_CORNER: 3 flat devices **
X_MXN0 VSSE NET19 NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET15 NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP4096X16CCHD4WD_CORNER
****
.SUBCKT RAMSP4096X16MEM_SLICE_CAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5
+  VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VNWP_0 VNWP_1 VSSE
** RAMSP4096X16MEM_SLICE_CAP_L: 518 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VSSE VSSE
+  RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROW9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VSSE VSSE RAMSP4096X16CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VDDC VDDC VNWP_0 VSSE VSSE RAMSP4096X16CCHD4_CORNER
XTOP_EDGE_ROWEDGER VDDC VDDC VNWP_1 VSSE VSSE RAMSP4096X16CCHD4WD_CORNER
.ENDS RAMSP4096X16MEM_SLICE_CAP_L
****
.SUBCKT RAMSP4096X16MEM_L_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_TOP_ROW: 772 flat devices **
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_2 VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_4 NBL[1]_4
+  NBL[2]_4 NBL[3]_4 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_4 VDDCE_4 VDDPE_4
+  VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_5 NBL[1]_5
+  NBL[2]_5 NBL[3]_5 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_5 VDDCE_5 VDDPE_5
+  VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
XMEM_L_COL_TOP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_TOP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_TOP_R0 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_TOP_R1 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
.ENDS RAMSP4096X16MEM_L_TOP_ROW
****
.SUBCKT RAMSP4096X16MEM_L_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14
+  VDDCE_15 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8
+  VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_0 VNWC_1 VNWC_2 VNWC_3
+  VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13
+  VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15
+  VSSE WL[0] WL[1]
** RAMSP4096X16MEM_L_MIDB_ROW: 772 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_384 NCORED01_386
+  NCORED10_388 NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396
+  NCORED31_398 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_416 NCORED01_418
+  NCORED10_420 NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428
+  NCORED31_430 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_448 NCORED01_450
+  NCORED10_452 NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460
+  NCORED31_462 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_480 NCORED01_482
+  NCORED10_484 NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492
+  NCORED31_494 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  RAMSP4096X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_256 NCORED01_258 NCORED10_260
+  NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268 NCORED31_270 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_288 NCORED01_290 NCORED10_292
+  NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300 NCORED31_302 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] RAMSP4096X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_17 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP4096X16CCHD4WD_EDG
.ENDS RAMSP4096X16MEM_L_MIDB_ROW
****
.SUBCKT RAMSP4096X16MEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8
+  NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14
+  NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWP_0 VNWP_1 VSSE WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4
+  WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13
+  WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21
+  WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29
+  WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37
+  WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45
+  WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53
+  WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61
+  WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69
+  WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77
+  WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85
+  WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93
+  WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101
+  WL[0]_102 WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108
+  WL[0]_109 WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115
+  WL[0]_116 WL[0]_117 WL[0]_118 WL[0]_119 WL[0]_120 WL[0]_121 WL[0]_122
+  WL[0]_123 WL[0]_124 WL[0]_125 WL[0]_126 WL[0]_127 WL[0]_128 WL[0]_129
+  WL[0]_130 WL[0]_131 WL[0]_132 WL[0]_133 WL[0]_134 WL[0]_135 WL[0]_136
+  WL[0]_137 WL[0]_138 WL[0]_139 WL[0]_140 WL[0]_141 WL[0]_142 WL[0]_143
+  WL[0]_144 WL[0]_145 WL[0]_146 WL[0]_147 WL[0]_148 WL[0]_149 WL[0]_150
+  WL[0]_151 WL[0]_152 WL[0]_153 WL[0]_154 WL[0]_155 WL[0]_156 WL[0]_157
+  WL[0]_158 WL[0]_159 WL[0]_160 WL[0]_161 WL[0]_162 WL[0]_163 WL[0]_164
+  WL[0]_165 WL[0]_166 WL[0]_167 WL[0]_168 WL[0]_169 WL[0]_170 WL[0]_171
+  WL[0]_172 WL[0]_173 WL[0]_174 WL[0]_175 WL[0]_176 WL[0]_177 WL[0]_178
+  WL[0]_179 WL[0]_180 WL[0]_181 WL[0]_182 WL[0]_183 WL[0]_184 WL[0]_185
+  WL[0]_186 WL[0]_187 WL[0]_188 WL[0]_189 WL[0]_190 WL[0]_191 WL[0]_192
+  WL[0]_193 WL[0]_194 WL[0]_195 WL[0]_196 WL[0]_197 WL[0]_198 WL[0]_199
+  WL[0]_200 WL[0]_201 WL[0]_202 WL[0]_203 WL[0]_204 WL[0]_205 WL[0]_206
+  WL[0]_207 WL[0]_208 WL[0]_209 WL[0]_210 WL[0]_211 WL[0]_212 WL[0]_213
+  WL[0]_214 WL[0]_215 WL[0]_216 WL[0]_217 WL[0]_218 WL[0]_219 WL[0]_220
+  WL[0]_221 WL[0]_222 WL[0]_223 WL[0]_224 WL[0]_225 WL[0]_226 WL[0]_227
+  WL[0]_228 WL[0]_229 WL[0]_230 WL[0]_231 WL[0]_232 WL[0]_233 WL[0]_234
+  WL[0]_235 WL[0]_236 WL[0]_237 WL[0]_238 WL[0]_239 WL[0]_240 WL[0]_241
+  WL[0]_242 WL[0]_243 WL[0]_244 WL[0]_245 WL[0]_246 WL[0]_247 WL[0]_248
+  WL[0]_249 WL[0]_250 WL[0]_251 WL[0]_252 WL[0]_253 WL[0]_254 WL[0]_255
+  WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8
+  WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16
+  WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24
+  WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32
+  WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40
+  WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48
+  WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56
+  WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64
+  WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72
+  WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80
+  WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88
+  WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96
+  WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103
+  WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110
+  WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115 WL[1]_116 WL[1]_117
+  WL[1]_118 WL[1]_119 WL[1]_120 WL[1]_121 WL[1]_122 WL[1]_123 WL[1]_124
+  WL[1]_125 WL[1]_126 WL[1]_127 WL[1]_128 WL[1]_129 WL[1]_130 WL[1]_131
+  WL[1]_132 WL[1]_133 WL[1]_134 WL[1]_135 WL[1]_136 WL[1]_137 WL[1]_138
+  WL[1]_139 WL[1]_140 WL[1]_141 WL[1]_142 WL[1]_143 WL[1]_144 WL[1]_145
+  WL[1]_146 WL[1]_147 WL[1]_148 WL[1]_149 WL[1]_150 WL[1]_151 WL[1]_152
+  WL[1]_153 WL[1]_154 WL[1]_155 WL[1]_156 WL[1]_157 WL[1]_158 WL[1]_159
+  WL[1]_160 WL[1]_161 WL[1]_162 WL[1]_163 WL[1]_164 WL[1]_165 WL[1]_166
+  WL[1]_167 WL[1]_168 WL[1]_169 WL[1]_170 WL[1]_171 WL[1]_172 WL[1]_173
+  WL[1]_174 WL[1]_175 WL[1]_176 WL[1]_177 WL[1]_178 WL[1]_179 WL[1]_180
+  WL[1]_181 WL[1]_182 WL[1]_183 WL[1]_184 WL[1]_185 WL[1]_186 WL[1]_187
+  WL[1]_188 WL[1]_189 WL[1]_190 WL[1]_191 WL[1]_192 WL[1]_193 WL[1]_194
+  WL[1]_195 WL[1]_196 WL[1]_197 WL[1]_198 WL[1]_199 WL[1]_200 WL[1]_201
+  WL[1]_202 WL[1]_203 WL[1]_204 WL[1]_205 WL[1]_206 WL[1]_207 WL[1]_208
+  WL[1]_209 WL[1]_210 WL[1]_211 WL[1]_212 WL[1]_213 WL[1]_214 WL[1]_215
+  WL[1]_216 WL[1]_217 WL[1]_218 WL[1]_219 WL[1]_220 WL[1]_221 WL[1]_222
+  WL[1]_223 WL[1]_224 WL[1]_225 WL[1]_226 WL[1]_227 WL[1]_228 WL[1]_229
+  WL[1]_230 WL[1]_231 WL[1]_232 WL[1]_233 WL[1]_234 WL[1]_235 WL[1]_236
+  WL[1]_237 WL[1]_238 WL[1]_239 WL[1]_240 WL[1]_241 WL[1]_242 WL[1]_243
+  WL[1]_244 WL[1]_245 WL[1]_246 WL[1]_247 WL[1]_248 WL[1]_249 WL[1]_250
+  WL[1]_251 WL[1]_252 WL[1]_253 WL[1]_254 WL[1]_255
** RAMSP4096X16MEMCORE_L: 199314 flat devices **
XMEM_L_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_1 WL[1]_1
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_10 WL[1]_10
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_100 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_100 WL[1]_100
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_101 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_101 WL[1]_101
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_102 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_102 WL[1]_102
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_103 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_103 WL[1]_103
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_104 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_104 WL[1]_104
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_105 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_105 WL[1]_105
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_106 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_106 WL[1]_106
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_107 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_107 WL[1]_107
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_108 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_108 WL[1]_108
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_109 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_109 WL[1]_109
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_11 WL[1]_11
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_110 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_110 WL[1]_110
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_111 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_111 WL[1]_111
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_112 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_112 WL[1]_112
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_113 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_113 WL[1]_113
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_114 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_114 WL[1]_114
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_115 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_115 WL[1]_115
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_116 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_116 WL[1]_116
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_117 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_117 WL[1]_117
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_118 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_118 WL[1]_118
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_119 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_119 WL[1]_119
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_12 WL[1]_12
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_120 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_120 WL[1]_120
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_121 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_121 WL[1]_121
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_122 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_122 WL[1]_122
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_123 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_123 WL[1]_123
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_124 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_124 WL[1]_124
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_125 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_125 WL[1]_125
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_129 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_129 WL[1]_129
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_13 WL[1]_13
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_130 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_130 WL[1]_130
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_131 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_131 WL[1]_131
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_132 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_132 WL[1]_132
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_133 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_133 WL[1]_133
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_134 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_134 WL[1]_134
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_135 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_135 WL[1]_135
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_136 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_136 WL[1]_136
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_137 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_137 WL[1]_137
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_138 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_138 WL[1]_138
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_139 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_139 WL[1]_139
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_14 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_14 WL[1]_14
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_140 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_140 WL[1]_140
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_141 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_141 WL[1]_141
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_142 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_142 WL[1]_142
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_143 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_143 WL[1]_143
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_144 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_144 WL[1]_144
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_145 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_145 WL[1]_145
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_146 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_146 WL[1]_146
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_147 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_147 WL[1]_147
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_148 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_148 WL[1]_148
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_149 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_149 WL[1]_149
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_15 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_15 WL[1]_15
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_150 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_150 WL[1]_150
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_151 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_151 WL[1]_151
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_152 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_152 WL[1]_152
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_153 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_153 WL[1]_153
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_154 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_154 WL[1]_154
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_155 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_155 WL[1]_155
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_156 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_156 WL[1]_156
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_157 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_157 WL[1]_157
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_158 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_158 WL[1]_158
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_159 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_159 WL[1]_159
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_16 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_16 WL[1]_16
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_160 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_160 WL[1]_160
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_161 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_161 WL[1]_161
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_162 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_162 WL[1]_162
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_163 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_163 WL[1]_163
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_164 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_164 WL[1]_164
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_165 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_165 WL[1]_165
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_166 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_166 WL[1]_166
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_167 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_167 WL[1]_167
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_168 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_168 WL[1]_168
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_169 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_169 WL[1]_169
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_17 WL[1]_17
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_170 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_170 WL[1]_170
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_171 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_171 WL[1]_171
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_172 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_172 WL[1]_172
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_173 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_173 WL[1]_173
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_174 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_174 WL[1]_174
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_175 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_175 WL[1]_175
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_176 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_176 WL[1]_176
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_177 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_177 WL[1]_177
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_178 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_178 WL[1]_178
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_179 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_179 WL[1]_179
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_18 WL[1]_18
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_180 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_180 WL[1]_180
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_181 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_181 WL[1]_181
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_182 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_182 WL[1]_182
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_183 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_183 WL[1]_183
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_184 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_184 WL[1]_184
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_185 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_185 WL[1]_185
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_186 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_186 WL[1]_186
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_187 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
+  BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9
+  BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10
+  BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC VNWC
+  VNWC VNWC VNWC VNWC VNWC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_187 WL[1]_187
+  RAMSP4096X16MEM_L_ROW
XMEM_L_ROW_188 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8
