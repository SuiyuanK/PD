* 
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Single Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.299um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 16 -b\
* Configuration: mux off -bus_notation on -check_instname on -diode\
* Configuration: s on -drive 6 -ema on -frequency 1.0 -instname RAM\
* Configuration: SP1024X16 -left_bus_delim "[" -mux 4 -mvt "" -name\
* Configuration: _case upper -power_type otc -prefix "" -pwr_gnd_re\
* Configuration: name vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention \
* Configuration: on -right_bus_delim "]" -ser none -site_def off -t\
* Configuration: op_layer m5-m10 -words 1024 -write_mask on -write_\
* Configuration: thru off -corners ff_1p10v_1p10v_0c,ff_1p10v_1p10v\
* Configuration: _125c,ff_1p10v_1p10v_m40c,ff_1p21v_1p21v_0c,ff_1p2\
* Configuration: 1v_1p21v_125c,ff_1p21v_1p21v_m40c,ff_1p26v_1p26v_0\
* Configuration: c,ff_1p26v_1p26v_125c,ff_1p26v_1p26v_85c,ff_1p26v_\
* Configuration: 1p26v_m40c,ss_0p90v_0p90v_0c,ss_0p90v_0p90v_125c,s\
* Configuration: s_0p90v_0p90v_m40c,ss_0p99v_0p99v_0c,ss_0p99v_0p99\
* Configuration: v_125c,ss_0p99v_0p99v_m40c,ss_1p08v_1p08v_0c,ss_1p\
* Configuration: 08v_1p08v_125c,ss_1p08v_1p08v_m40c,tt_1p00v_1p00v_\
* Configuration: 125c,tt_1p00v_1p00v_25c,tt_1p00v_1p00v_85c,tt_1p10\
* Configuration: v_1p10v_125c,tt_1p10v_1p10v_25c,tt_1p10v_1p10v_85c\
* Configuration: ,tt_1p20v_1p20v_125c,tt_1p20v_1p20v_25c,tt_1p20v_1\
* Configuration: p20v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RAMSP1024X16BOTCAP4 D LOG0 Q TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN
+  WENY
** RAMSP1024X16BOTCAP4: 4 flat devices **
DI77.D_Diode_X_dio VPW WEN NDIO11LL AREA=0.035P PJ=0.78U
DI78.D_Diode_X_dio VPW TWEN NDIO11LL AREA=0.035P PJ=0.78U
DI80.D_Diode_X_dio VPW D NDIO11LL AREA=0.035P PJ=0.78U
DI82.D_Diode_X_dio VPW TD NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP1024X16BOTCAP4
****
.SUBCKT RAMSP1024X16BOTCAP4_RPT D LOG0 Q VDDCE VNWP VPW WEN WENY
** RAMSP1024X16BOTCAP4_RPT: 4 flat devices **
XI0 D LOG0 Q LOG0 LOG0 VDDCE VNWP VNWP VPW VPW VPW WEN WENY
+  RAMSP1024X16BOTCAP4
.ENDS RAMSP1024X16BOTCAP4_RPT
****
.SUBCKT RAMSP1024X16MIDBOT_BIST CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2
+  EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LOG0 NWCLK PEN PENSI PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0
+  TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5
+  VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP1024X16MIDBOT_BIST: 60 flat devices **
DI100.D_Diode_X_dio VPW FCA1_3 NDIO11LL AREA=0.035P PJ=0.78U
DI102.D_Diode_X_dio VPW CRE1 NDIO11LL AREA=0.035P PJ=0.78U
DI104.D_Diode_X_dio VPW RA5 NDIO11LL AREA=0.035P PJ=0.78U
DI106.D_Diode_X_dio VPW RA3 NDIO11LL AREA=0.035P PJ=0.78U
DI107.D_Diode_X_dio VPW RA4 NDIO11LL AREA=0.035P PJ=0.78U
DI108.D_Diode_X_dio VPW LA2 NDIO11LL AREA=0.035P PJ=0.78U
DI110.D_Diode_X_dio VPW LA1 NDIO11LL AREA=0.035P PJ=0.78U
DI111.D_Diode_X_dio VPW RA2 NDIO11LL AREA=0.035P PJ=0.78U
DI112.D_Diode_X_dio VPW RA1 NDIO11LL AREA=0.035P PJ=0.78U
DI114.D_Diode_X_dio VPW LA0 NDIO11LL AREA=0.035P PJ=0.78U
DI115.D_Diode_X_dio VPW CA2 NDIO11LL AREA=0.035P PJ=0.78U
DI117.D_Diode_X_dio VPW RA0 NDIO11LL AREA=0.035P PJ=0.78U
DI118.D_Diode_X_dio VPW TPEN NDIO11LL AREA=0.035P PJ=0.78U
DI119.D_Diode_X_dio VPW PEN NDIO11LL AREA=0.035P PJ=0.78U
DI120.D_Diode_X_dio VPW TGWEN NDIO11LL AREA=0.035P PJ=0.78U
DI121.D_Diode_X_dio VPW TCEN NDIO11LL AREA=0.035P PJ=0.78U
DI122.D_Diode_X_dio VPW CA0 NDIO11LL AREA=0.035P PJ=0.78U
DI123.D_Diode_X_dio VPW PENSI NDIO11LL AREA=0.035P PJ=0.78U
DI124.D_Diode_X_dio VPW CA1 NDIO11LL AREA=0.035P PJ=0.78U
DI125.D_Diode_X_dio VPW TLA1 NDIO11LL AREA=0.035P PJ=0.78U
DI126.D_Diode_X_dio VPW TLA2 NDIO11LL AREA=0.035P PJ=0.78U
DI127.D_Diode_X_dio VPW TRA4 NDIO11LL AREA=0.035P PJ=0.78U
DI128.D_Diode_X_dio VPW TRA5 NDIO11LL AREA=0.035P PJ=0.78U
DI129.D_Diode_X_dio VPW TRA3 NDIO11LL AREA=0.035P PJ=0.78U
DI130.D_Diode_X_dio VPW TRA2 NDIO11LL AREA=0.035P PJ=0.78U
DI131.D_Diode_X_dio VPW TLA0 NDIO11LL AREA=0.035P PJ=0.78U
DI132.D_Diode_X_dio VPW TCA2 NDIO11LL AREA=0.035P PJ=0.78U
DI133.D_Diode_X_dio VPW TRA0 NDIO11LL AREA=0.035P PJ=0.78U
DI134.D_Diode_X_dio VPW TRA1 NDIO11LL AREA=0.035P PJ=0.78U
DI135.D_Diode_X_dio VPW TCA1 NDIO11LL AREA=0.035P PJ=0.78U
DI136.D_Diode_X_dio VPW TCA0 NDIO11LL AREA=0.035P PJ=0.78U
DI137.D_Diode_X_dio VPW GWEN NDIO11LL AREA=0.035P PJ=0.78U
DI138.D_Diode_X_dio VPW CEN NDIO11LL AREA=0.035P PJ=0.78U
DI139.D_Diode_X_dio VPW RDT NDIO11LL AREA=0.035P PJ=0.78U
DI140.D_Diode_X_dio VPW TEN NDIO11LL AREA=0.035P PJ=0.78U
DI142.D_Diode_X_dio VPW DFTRAMBYP NDIO11LL AREA=0.035P PJ=0.78U
DI146.D_Diode_X_dio VPW EMA2 NDIO11LL AREA=0.035P PJ=0.78U
DI147.D_Diode_X_dio VPW EMA1 NDIO11LL AREA=0.035P PJ=0.78U
DI148.D_Diode_X_dio VPW EMA0 NDIO11LL AREA=0.035P PJ=0.78U
DI151.D_Diode_X_dio VPW EMAW0 NDIO11LL AREA=0.035P PJ=0.78U
DI152.D_Diode_X_dio VPW EMAW1 NDIO11LL AREA=0.035P PJ=0.78U
DI154.D_Diode_X_dio VPW CLK NDIO11LL AREA=0.035P PJ=0.78U
DI157.D_Diode_X_dio VPW SE NDIO11LL AREA=0.035P PJ=0.78U
DI158.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
DI159.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
DI160.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
DI61.D_Diode_X_dio VPW FCA1_0 NDIO11LL AREA=0.035P PJ=0.78U
DI65.D_Diode_X_dio VPW FCA1_1 NDIO11LL AREA=0.035P PJ=0.78U
DI66.D_Diode_X_dio VPW FCA1_2 NDIO11LL AREA=0.035P PJ=0.78U
DI77.D_Diode_X_dio VPW FCA2_6 NDIO11LL AREA=0.035P PJ=0.78U
DI90.D_Diode_X_dio VPW FCA2_4 NDIO11LL AREA=0.035P PJ=0.78U
DI91.D_Diode_X_dio VPW FCA2_5 NDIO11LL AREA=0.035P PJ=0.78U
DI92.D_Diode_X_dio VPW FCA2_2 NDIO11LL AREA=0.035P PJ=0.78U
DI93.D_Diode_X_dio VPW FCA2_1 NDIO11LL AREA=0.035P PJ=0.78U
DI94.D_Diode_X_dio VPW FCA2_3 NDIO11LL AREA=0.035P PJ=0.78U
DI95.D_Diode_X_dio VPW FCA1_6 NDIO11LL AREA=0.035P PJ=0.78U
DI96.D_Diode_X_dio VPW FCA1_4 NDIO11LL AREA=0.035P PJ=0.78U
DI97.D_Diode_X_dio VPW FCA1_5 NDIO11LL AREA=0.035P PJ=0.78U
DI98.D_Diode_X_dio VPW FCA2_0 NDIO11LL AREA=0.035P PJ=0.78U
DI99.D_Diode_X_dio VPW CRE2 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP1024X16MIDBOT_BIST
****
.SUBCKT RAMSP1024X16MIDBOT_BIST_WRAPT CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK
+  CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1
+  EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1
+  LAY2 LOG0 NWCLK PEN PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2
+  TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
** RAMSP1024X16MIDBOT_BIST_WRAPT: 60 flat devices **
XI0 CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP DUMMY_DWL_R
+  DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0 FCA1_1
+  FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4
+  FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN PENSI
+  PENSO PGEN PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N RET2N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN
+  TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE VDDC_L VDDC_R
+  VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE RAMSP1024X16MIDBOT_BIST
.ENDS RAMSP1024X16MIDBOT_BIST_WRAPT
****
.SUBCKT RAMSP1024X16BOTCORNER LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP1024X16BOTCORNER: 2 flat devices **
DI74.D_Diode_X_dio VPW PSI NDIO11LL AREA=0.035P PJ=0.78U
DI85.D_Diode_X_dio VPW SI NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMSP1024X16BOTCORNER
****
.SUBCKT RAMSP1024X16BOTCORNER_WRAPT LOG0 PSI SI VNWC VNWP VPW VSS
** RAMSP1024X16BOTCORNER_WRAPT: 2 flat devices **
XI0 LOG0 PSI SI VNWC VNWP VPW VSS RAMSP1024X16BOTCORNER
.ENDS RAMSP1024X16BOTCORNER_WRAPT
****
.SUBCKT RAMSP1024X16BOTCAPROW CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DFTRAMBYP DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMA0 EMA1 EMA2 EMAW0
+  EMAW1 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2
+  FCA2_3 FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0
+  NWCLK PEN PENSI PENSO PSI_0 PSI_1 PSO0 PSO1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RDT RET1N SE SEL_D SEL_SI SEL_TD SI_0 SI_1 SO0 SO1 TCA0
+  TCA1 TCA2 TCEN TEN TGWEN TLA0 TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC_0 VNWC_1 VNWC_2 VNWP VPW VSSE WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10
+  WENY_11 WENY_12 WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMSP1024X16BOTCAPROW: 128 flat devices **
XCENTRE CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DFTRAMBYP
+  DUMMY_DWL_R DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GWEN GWENY LA0 LA1 LA2 LAY0 LAY1 LAY2 LOG0 NWCLK PEN
+  PENSI PENSO PSO0 PSO1 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RDT RET1N SE SEL_D SEL_SI SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TEN TGWEN TLA0
+  TLA1 TLA2 TPEN TRA0 TRA1 TRA2 TRA3 TRA4 TRA5 VDDCE_8 VDDC_L VDDC_R VDDPE
+  VDDP_CLKGEN VNWC_1 VNWP VPW VPW VSSE RAMSP1024X16MIDBOT_BIST_WRAPT
XLEFT LOG0 PSI_0 SI_0 VNWC_0 VNWP VPW VPW RAMSP1024X16BOTCORNER_WRAPT
XLEFT_COL_0 D_0 LOG0 Q_0 VDDCE_0 VNWP VPW WEN_0 WENY_0 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_1 D_1 LOG0 Q_1 VDDCE_1 VNWP VPW WEN_1 WENY_1 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_2 D_2 LOG0 Q_2 VDDCE_2 VNWP VPW WEN_2 WENY_2 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_3 D_3 LOG0 Q_3 VDDCE_3 VNWP VPW WEN_3 WENY_3 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_4 D_4 LOG0 Q_4 VDDCE_4 VNWP VPW WEN_4 WENY_4 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_5 D_5 LOG0 Q_5 VDDCE_5 VNWP VPW WEN_5 WENY_5 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_6 D_6 LOG0 Q_6 VDDCE_6 VNWP VPW WEN_6 WENY_6 RAMSP1024X16BOTCAP4_RPT
XLEFT_COL_7 D_7 LOG0 Q_7 VDDCE_7 VNWP VPW WEN_7 WENY_7 RAMSP1024X16BOTCAP4_RPT
XRIGHT LOG0 PSI_1 SI_1 VNWC_2 VNWP VPW VPW RAMSP1024X16BOTCORNER_WRAPT
XRIGHT_COL_0 D_8 LOG0 Q_8 VDDCE_9 VNWP VPW WEN_8 WENY_8
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_1 D_9 LOG0 Q_9 VDDCE_10 VNWP VPW WEN_9 WENY_9
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_2 D_10 LOG0 Q_10 VDDCE_11 VNWP VPW WEN_10 WENY_10
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_3 D_11 LOG0 Q_11 VDDCE_12 VNWP VPW WEN_11 WENY_11
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_4 D_12 LOG0 Q_12 VDDCE_13 VNWP VPW WEN_12 WENY_12
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_5 D_13 LOG0 Q_13 VDDCE_14 VNWP VPW WEN_13 WENY_13
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_6 D_14 LOG0 Q_14 VDDCE_15 VNWP VPW WEN_14 WENY_14
+  RAMSP1024X16BOTCAP4_RPT
XRIGHT_COL_7 D_15 LOG0 Q_15 VDDCE_16 VNWP VPW WEN_15 WENY_15
+  RAMSP1024X16BOTCAP4_RPT
.ENDS RAMSP1024X16BOTCAPROW
****
.SUBCKT RAMSP1024X16COLM4_BIST_WM BL0 BL1 BL2 BL3 BLPRECH D DFTRAMBYP
+  DUMMY_DWL_L DUMMY_DWL_R DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R
+  DUM_SEL_TD_L DUM_SEL_TD_R DUM_SI DUM_SO DWL LOG0 NACT_CC NBL0 NBL1 NBL2
+  NBL3 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO SAPRECH SEL_D SEL_SI
+  SEL_TD SI SO TD TE TWEN TWENL TWENR TWEN_PRG VDDC VDDCE VDDPE VNWC VNWP VPW
+  VSS VSSE WEN WENL WENR WENY WEN_PRG YW0 YW1 YW2 YW3
** RAMSP1024X16COLM4_BIST_WM: 161 flat devices **
X_M_cd.I34.MXNA1 _CD.NBLPRECH BLPRECH VSS VPW N11LL_CKT W=0.395U L=0.04U
X_M_cd.I34.MXPA1 _CD.NBLPRECH BLPRECH VDDPE VNWP P11LL_CKT W=0.87U L=0.04U
X_M_cd.I46.MXNA1 _CD.SAE NSAE VSS VPW N11LL_CKT W=0.32U L=0.04U
X_M_cd.I46.MXPA1 _CD.SAE NSAE VDDPE VNWP P11LL_CKT W=0.385U L=0.04U
X_M_cd.I56.MXNA1 _CD.NSAPRECH SAPRECH _CD.I56.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_cd.I56.MXNA2 _CD.I56.N1 NSAE VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_cd.I56.MXPA1 _CD.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_cd.I56.MXPA2 _CD.NSAPRECH NSAE VDDPE VNWP P11LL_CKT W=0.3U L=0.04U
X_M_cd.MXN0 _CD.SAINT LOG0 VSS VPW N11LL_CKT W=1.175U L=0.04U
X_M_cd._cdrw0._mx0.MXN0 NBL0 YW0 WRZERO VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXN1 BL0 YW0 WRONE VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXP1 NBL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP10 _CD._CDRW0._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx0.MXP3 _CD.NSD NYR0 NBL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP4 _CD.SD NYR0 BL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP5 NBL0 BL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx0.MXP7 BL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP8 NBL0 _CD.NBLPRECH BL0 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP9 BL0 NBL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXN0 NBL1 YW1 WRZERO VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXN1 BL1 YW1 WRONE VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXP1 NBL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP10 _CD._CDRW0._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx1.MXP3 _CD.NSD NYR1 NBL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP4 _CD.SD NYR1 BL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP5 NBL1 BL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXP7 BL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP8 NBL1 _CD.NBLPRECH BL1 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP9 BL1 NBL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXN0 NBL2 YW2 WRZERO VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXN1 BL2 YW2 WRONE VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXP1 NBL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP10 _CD._CDRW1._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx0.MXP3 _CD.NSD NYR2 NBL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP4 _CD.SD NYR2 BL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP5 NBL2 BL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXP7 BL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP8 NBL2 _CD.NBLPRECH BL2 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP9 BL2 NBL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXN0 NBL3 YW3 WRZERO VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXN1 BL3 YW3 WRONE VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXP1 NBL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP10 _CD._CDRW1._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx1.MXP3 _CD.NSD NYR3 NBL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP4 _CD.SD NYR3 BL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP5 NBL3 BL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXP7 BL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP8 NBL3 _CD.NBLPRECH BL3 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP9 BL3 NBL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._dwl_load_0.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._dwl_load_1.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.6U L=0.06U
X_M_cd._sa1.MXN17 _CD.NSD _CD.SD _CD.SAINT VPW N11LL_CKT W=2.36U L=0.085U
X_M_cd._sa1.MXN18 _CD.SAINT _CD.SAE VSS VPW N11LL_CKT W=1.175U L=0.04U
X_M_cd._sa1.MXN19 _CD.SD _CD.NSD _CD.SAINT VPW N11LL_CKT W=2.36U L=0.085U
X_M_cd._sa1.MXP24 _CD.NSD _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP25 _CD.NSD _CD.NSAPRECH _CD.SD VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP26 _CD.SD _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP27 _CD.NSD _CD.SD VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXP28 _CD.SD _CD.NSD VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._salat1.I62.MXNA1 SAO _CD._SALAT1.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat1.I62.MXPA1 SAO _CD._SALAT1.SD_LAT VDDPE VNWP P11LL_CKT W=0.63U
+  L=0.04U
X_M_cd._salat1.I68.MXNA1 _CD._SALAT1.WCLK_WT NWCLK_WT VSS VPW N11LL_CKT W=0.2U
+  L=0.04U
X_M_cd._salat1.I68.MXPA1 _CD._SALAT1.WCLK_WT NWCLK_WT VDDPE VNWP P11LL_CKT
+  W=0.21U L=0.04U
X_M_cd._salat1.I69.MXNA1 _CD._SALAT1.I69.N1 D_WT VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._salat1.I69.MXNOE _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I69.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I69.MXPA1 _CD._SALAT1.I69.P1 D_WT VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.I69.MXPOEN _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I69.P1 VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXNA1 _CD._SALAT1.I70.N1 _CD._SALAT1.SD_LAT VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXNOE _CD._SALAT1.NSD_LAT NWCLK_WT _CD._SALAT1.I70.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cd._salat1.I70.MXPA1 _CD._SALAT1.I70.P1 _CD._SALAT1.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I70.MXPOEN _CD._SALAT1.NSD_LAT _CD._SALAT1.WCLK_WT
+  _CD._SALAT1.I70.P1 VNWP P11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I82.MXNA1 _CD._SALAT1.NLAT_E _CD.SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat1.I82.MXPA1 _CD._SALAT1.NLAT_E _CD.SAE VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_cd._salat1.MXN8 _CD._SALAT1.N1B _CD._SALAT1.NSD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.MXN9 _CD._SALAT1.SD_LAT _CD._SALAT1.NLAT_E _CD._SALAT1.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat1.MXP6 _CD._SALAT1.SD_LAT _CD.SAE _CD._SALAT1.P1B VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXP7 _CD._SALAT1.P1B _CD._SALAT1.NSD_LAT VDDPE VNWP P11LL_CKT
+  W=0.47U L=0.04U
X_M_cd._salat1.MXPs _CD._SALAT1.SD_LAT _CD.NSD _CD._SALAT1.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat1.MX_ndmy _CD._SALAT1.NSD_DUM _CD.SD _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.MX_nlat _CD._SALAT1.N1A _CD.SAE VSS VPW N11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.MX_pdmy _CD._SALAT1.NSD_DUM _CD.SD _CD._SALAT1.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_pnsae _CD._SALAT1.P1A _CD._SALAT1.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_sd_n _CD._SALAT1.SD_LAT _CD.NSD _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_wr.I176.MXNA1 SO SAO VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_wr.I176.MXPA1 SO SAO VDDPE VNWP P11LL_CKT W=0.145U L=0.04U
X_M_wr.I203.MXNA1 _WR.ND_LAT _WR.D_LAT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I203.MXPA1 _WR.ND_LAT _WR.D_LAT VDDPE VNWP P11LL_CKT W=0.25U L=0.04U
X_M_wr.I205.MXNA1 D_WT _WR.ND_LAT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr.I205.MXPA1 D_WT _WR.ND_LAT VDDPE VNWP P11LL_CKT W=0.25U L=0.04U
X_M_wr.I221.MXNA1 _WR.WCLK NWCLK VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr.I221.MXPA1 _WR.WCLK NWCLK VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I224.MXNA1 _WR.INWCLK _WR.WCLK VSS VPW N11LL_CKT W=0.21U L=0.04U
X_M_wr.I224.MXPA1 _WR.INWCLK _WR.WCLK VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat.I1_0.MXNA1 _WR._DLAT.NSEL3 SEL_SI VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_0.MXPA1 _WR._DLAT.NSEL3 SEL_SI VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_1.MXNA1 _WR._DLAT.NSEL2 SEL_TD VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_1.MXPA1 _WR._DLAT.NSEL2 SEL_TD VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_2.MXNA1 _WR._DLAT.NSEL1 SEL_D VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I1_2.MXPA1 _WR._DLAT.NSEL1 SEL_D VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I50.MXNA1 _WR.D_LAT _WR.DLAT_NQ VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.I50.MXPA1 _WR.D_LAT _WR.DLAT_NQ VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat.I55.MXNA1 _WR._DLAT.I55.N1 _WR.D_LAT VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I55.MXNOE _WR.DLAT_NQ _WR.WCLK _WR._DLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat.I55.MXPA1 _WR._DLAT.I55.P1 _WR.D_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat.I55.MXPOEN _WR.DLAT_NQ _WR.INWCLK _WR._DLAT.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat.I65.MXNOE _WR.DLAT_NQ _WR.INWCLK _WR._DLAT.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._dlat.I65.MXPOEN _WR.DLAT_NQ _WR.WCLK _WR._DLAT.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXN1 _WR._DLAT.N2 TD VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN2 _WR._DLAT.N1 D VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN3 _WR._DLAT.ND SEL_D _WR._DLAT.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXN4 _WR._DLAT.ND SEL_TD _WR._DLAT.N2 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXN5 _WR._DLAT.N3 SI VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat.MXN6 _WR._DLAT.ND SEL_SI _WR._DLAT.N3 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat.MXP0 _WR._DLAT.ND _WR._DLAT.NSEL1 _WR._DLAT.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP1 _WR._DLAT.P1 D VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat.MXP2 _WR._DLAT.ND _WR._DLAT.NSEL2 _WR._DLAT.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP3 _WR._DLAT.P2 TD VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat.MXP4 _WR._DLAT.ND _WR._DLAT.NSEL3 _WR._DLAT.P3 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat.MXP5 _WR._DLAT.P3 SI VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._tri.I169.MXNA1 _WR._TRI.NET127 _WR.WEN_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri.I169.MXNA2 _WR._TRI.NET127 _WR.D_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri.I169.MXPA1 _WR._TRI.NET127 _WR.WEN_LAT _WR._TRI.I169.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri.I169.MXPA2 _WR._TRI.I169.P1 _WR.D_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri.I179.MXNA1 _WR._TRI.NET120 _WR.WEN_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri.I179.MXNA2 _WR._TRI.NET120 _WR.ND_LAT VSS VPW N11LL_CKT W=0.18U
+  L=0.04U
X_M_wr._tri.I179.MXPA1 _WR._TRI.NET120 _WR.WEN_LAT _WR._TRI.I179.P1 VNWP
+  P11LL_CKT W=0.545U L=0.04U
X_M_wr._tri.I179.MXPA2 _WR._TRI.I179.P1 _WR.ND_LAT VDDPE VNWP P11LL_CKT
+  W=0.545U L=0.04U
X_M_wr._tri.MXN0 WRONE _WR._TRI.NET127 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri.MXN1 WRZERO _WR._TRI.NET120 VSS VPW N11LL_CKT W=1.545U L=0.04U
X_M_wr._tri.MXP0 _WR._TRI.HZWRONE _WR.WEN_LAT VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri.MXP1 WRONE _WR._TRI.NET127 _WR._TRI.HZWRONE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri.MXP11 _WR._TRI.HZWRONE _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri.MXP12 _WR._TRI.HZWRZERO _WR.WCLK VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._tri.MXP2 WRZERO _WR._TRI.NET120 _WR._TRI.HZWRZERO VNWP P11LL_CKT
+  W=0.44U L=0.04U
X_M_wr._tri.MXP3 _WR._TRI.HZWRZERO _WR.WEN_LAT VDDPE VNWP P11LL_CKT W=0.44U
+  L=0.04U
X_M_wr._wenmux0.I0.MXNA1 _WR._WENMUX0.NDY _WR._WENMUX0.IDY _WR._WENMUX0.I0.N1
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXNA2 _WR._WENMUX0.I0.N1 DFTRAMBYP VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXPA1 _WR._WENMUX0.NDY _WR._WENMUX0.IDY VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_wr._wenmux0.I0.MXPA2 _WR._WENMUX0.NDY DFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_M_wr._wenmux0.I50.MXNA1 _WR.WEN_LAT _WR.WE_LAT VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._wenmux0.I50.MXPA1 _WR.WEN_LAT _WR.WE_LAT VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._wenmux0.I55.MXNA1 _WR._WENMUX0.I55.N1 _WR.WEN_LAT VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXNOE _WR.WE_LAT _WR.WCLK _WR._WENMUX0.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXPA1 _WR._WENMUX0.I55.P1 _WR.WEN_LAT VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I55.MXPOEN _WR.WE_LAT _WR.INWCLK _WR._WENMUX0.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenmux0.I57.MXNA1 _WR._WENMUX0.NSEL TE VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenmux0.I57.MXPA1 _WR._WENMUX0.NSEL TE VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._wenmux0.I62.MXNA1 WENY _WR._WENMUX0.NDY VSS VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_wr._wenmux0.I62.MXPA1 WENY _WR._WENMUX0.NDY VDDPE VNWP P11LL_CKT W=1.12U
+  L=0.04U
X_M_wr._wenmux0.I63.MXNA1 _WR._WENMUX0.IDY _WR._WENMUX0.ND VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._wenmux0.I63.MXPA1 _WR._WENMUX0.IDY _WR._WENMUX0.ND VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._wenmux0.I65.MXNOE _WR.WE_LAT _WR.INWCLK _WR._WENMUX0.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.I65.MXPOEN _WR.WE_LAT _WR.WCLK _WR._WENMUX0.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXN1 _WR._WENMUX0.ND TWEN_PRG _WR._WENMUX0.N2 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN2 _WR._WENMUX0.ND WEN_PRG _WR._WENMUX0.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN5 _WR._WENMUX0.N1 _WR._WENMUX0.NSEL VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._wenmux0.MXN6 _WR._WENMUX0.N2 TE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._wenmux0.MXP1 _WR._WENMUX0.ND WEN_PRG _WR._WENMUX0.P1 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXP3 _WR._WENMUX0.ND TWEN_PRG _WR._WENMUX0.P2 VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._wenmux0.MXP4 _WR._WENMUX0.P1 TE VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._wenmux0.MXP5 _WR._WENMUX0.P2 _WR._WENMUX0.NSEL VDDPE VNWP P11LL_CKT
+  W=0.42U L=0.04U
.ENDS RAMSP1024X16COLM4_BIST_WM
****
.SUBCKT RAMSP1024X16IOCDM_L BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL2_0 BL2_1 BL2_2 BL2_3
+  BL2_4 BL2_5 BL2_6 BL2_7 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BLPRECH DFTRAMBYP DUMMY_DWL_L DUMMY_DWL_R DUM_SEL_D_L DUM_SEL_D_R
+  DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L DUM_SEL_TD_R DUM_SI DUM_SO DWL D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0 NACT_CC NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL0_4
+  NBL0_5 NBL0_6 NBL0_7 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4 NBL1_5 NBL1_6
+  NBL1_7 NBL2_0 NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6 NBL2_7 NBL3_0
+  NBL3_1 NBL3_2 NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH
+  SEL_D SEL_SI SEL_TD SI SO TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL
+  TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC_0 VNWC_1 VNWC_2
+  VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7 VPW WENL WENR WENY_0 WENY_1 WENY_2
+  WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 YW0 YW1 YW2 YW3
** RAMSP1024X16IOCDM_L: 1288 flat devices **
XL_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D_1 DFTRAMBYP DUMMY_DWL_R_56
+  DUMMY_DWL_R_72 DUM_SEL_D_R_48 DUM_SEL_D_R_64 DUM_SEL_SI_R_50
+  DUM_SEL_SI_R_66 DUM_SEL_TD_R_52 DUM_SEL_TD_R_68 DUM_SO_54 DUM_SO_70 DWL
+  LOG0 NACT_CC NBL0_1 NBL1_1 NBL2_1 NBL3_1 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_1 SAPRECH SEL_D SEL_SI SEL_TD SO_58 SO_74 TD_1 TE TWEN_1 TWENR_60
+  TWENR_76 TWEN_1 VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW WEN_1 WENR_62
+  WENR_78 WENY_1 WEN_1 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D_2 DFTRAMBYP DUMMY_DWL_R_72
+  DUMMY_DWL_R_88 DUM_SEL_D_R_64 DUM_SEL_D_R_80 DUM_SEL_SI_R_66
+  DUM_SEL_SI_R_82 DUM_SEL_TD_R_68 DUM_SEL_TD_R_84 DUM_SO_70 DUM_SO_86 DWL
+  LOG0 NACT_CC NBL0_2 NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_2 SAPRECH SEL_D SEL_SI SEL_TD SO_74 SO_90 TD_2 TE TWEN_2 TWENR_76
+  TWENR_92 TWEN_2 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW WEN_2 WENR_78
+  WENR_94 WENY_2 WEN_2 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_I3 BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D_3 DFTRAMBYP DUMMY_DWL_R_88
+  DUMMY_DWL_R_104 DUM_SEL_D_R_80 DUM_SEL_D_R_96 DUM_SEL_SI_R_82
+  DUM_SEL_SI_R_98 DUM_SEL_TD_R_84 DUM_SEL_TD_R_100 DUM_SO_86 DUM_SO_102 DWL
+  LOG0 NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_3 SAPRECH SEL_D SEL_SI SEL_TD SO_90 SO_106 TD_3 TE TWEN_3 TWENR_92
+  TWENR_108 TWEN_3 VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW WEN_3 WENR_94
+  WENR_110 WENY_3 WEN_3 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_I4 BL0_4 BL1_4 BL2_4 BL3_4 BLPRECH D_4 DFTRAMBYP DUMMY_DWL_R_104
+  DUMMY_DWL_L_24 DUM_SEL_D_R_96 DUM_SEL_D_L_16 DUM_SEL_SI_R_98
+  DUM_SEL_SI_L_18 DUM_SEL_TD_R_100 DUM_SEL_TD_L_20 DUM_SO_102 DUM_SI_22 DWL
+  LOG0 NACT_CC NBL0_4 NBL1_4 NBL2_4 NBL3_4 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_4 SAPRECH SEL_D SEL_SI SEL_TD SO_106 SI_26 TD_4 TE TWEN_4
+  TWENR_108 TWENL_28 TWEN_4 VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW WEN_4
+  WENR_110 WENL_30 WENY_4 WEN_4 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_I5 BL0_5 BL1_5 BL2_5 BL3_5 BLPRECH D_5 DFTRAMBYP DUMMY_DWL_L_24
+  DUMMY_DWL_R_8 DUM_SEL_D_L_16 DUM_SEL_D_R_0 DUM_SEL_SI_L_18 DUM_SEL_SI_R_2
+  DUM_SEL_TD_L_20 DUM_SEL_TD_R_4 DUM_SI_22 DUM_SO_6 DWL LOG0 NACT_CC NBL0_5
+  NBL1_5 NBL2_5 NBL3_5 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_5 SAPRECH
+  SEL_D SEL_SI SEL_TD SI_26 SO_10 TD_5 TE TWEN_5 TWENL_28 TWENR_12 TWEN_5
+  VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW WEN_5 WENL_30 WENR_14 WENY_5
+  WEN_5 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_I6 BL0_6 BL1_6 BL2_6 BL3_6 BLPRECH D_6 DFTRAMBYP DUMMY_DWL_R_8
+  DUMMY_DWL_R_40 DUM_SEL_D_R_0 DUM_SEL_D_R_32 DUM_SEL_SI_R_2 DUM_SEL_SI_R_34
+  DUM_SEL_TD_R_4 DUM_SEL_TD_R_36 DUM_SO_6 DUM_SO_38 DWL LOG0 NACT_CC NBL0_6
+  NBL1_6 NBL2_6 NBL3_6 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_6 SAPRECH
+  SEL_D SEL_SI SEL_TD SO_10 SO_42 TD_6 TE TWEN_6 TWENR_12 TWENR_44 TWEN_6
+  VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW WEN_6 WENR_14 WENR_46 WENY_6
+  WEN_6 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D_0 DFTRAMBYP DUMMY_DWL_L
+  DUMMY_DWL_R_56 DUM_SEL_D_L DUM_SEL_D_R_48 DUM_SEL_SI_L DUM_SEL_SI_R_50
+  DUM_SEL_TD_L DUM_SEL_TD_R_52 DUM_SI DUM_SO_54 DWL LOG0 NACT_CC NBL0_0
+  NBL1_0 NBL2_0 NBL3_0 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_0 SAPRECH
+  SEL_D SEL_SI SEL_TD SI SO_58 TD_0 TE TWEN_0 TWENL TWENR_60 TWEN_0 VDDC_0
+  VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW WEN_0 WENL WENR_62 WENY_0 WEN_0 YW0
+  YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XL_IO_R BL0_7 BL1_7 BL2_7 BL3_7 BLPRECH D_7 DFTRAMBYP DUMMY_DWL_R_40
+  DUMMY_DWL_R DUM_SEL_D_R_32 DUM_SEL_D_R DUM_SEL_SI_R_34 DUM_SEL_SI_R
+  DUM_SEL_TD_R_36 DUM_SEL_TD_R DUM_SO_38 DUM_SO DWL LOG0 NACT_CC NBL0_7
+  NBL1_7 NBL2_7 NBL3_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_7 SAPRECH
+  SEL_D SEL_SI SEL_TD SO_42 SO TD_7 TE TWEN_7 TWENR_44 TWENR TWEN_7 VDDC_7
+  VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW WEN_7 WENR_46 WENR WENY_7 WEN_7 YW0
+  YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
.ENDS RAMSP1024X16IOCDM_L
****
.SUBCKT RAMSP1024X16FLCOLM4_BIST_WM BLPRECH DFTRAMBYP DUMMY_DWL DUM_SEL_D
+  DUM_SEL_SI DUM_SEL_TD DUM_SI DWL LOG0 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1
+  NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD SI TE TWEN VDDCE VDDPE VNWC VNWP VPW
+  VSS VSSE WEN YW0 YW1 YW2 YW3
** RAMSP1024X16FLCOLM4_BIST_WM: 2 flat devices **
X_MXN18 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN19 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.31U L=0.085U
.ENDS RAMSP1024X16FLCOLM4_BIST_WM
****
.SUBCKT RAMSP1024X16CCHD4_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP1024X16CCHD4_CORNER: 3 flat devices **
X_MXN0 VSSE NET17 NET16 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET21 NET20 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET25 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4_CORNER
****
.SUBCKT RAMSP1024X16IOEDGE BLPRECH DFTRAMBYP DUMMY_DWL DUM_SEL_D DUM_SEL_SI_0
+  DUM_SEL_SI_1 DUM_SEL_TD_0 DUM_SEL_TD_1 DUM_SI_0 DUM_SI_1 DWL LOG0 NACT_CC
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD SI TE
+  TWEN VDDC VDDCE VDDPE VNWC VPW VSS_0 VSS_1 WEN YW0 YW1 YW2 YW3
** RAMSP1024X16IOEDGE: 5 flat devices **
XCOLM_EDGE BLPRECH DFTRAMBYP DUMMY_DWL DUM_SEL_D DUM_SEL_SI_1 DUM_SEL_TD_1
+  DUM_SI_1 DWL LOG0 NACT_CC NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAPRECH
+  SEL_D SEL_SI SEL_TD SI TE TWEN VDDCE VDDPE VNWC VDDPE VPW VSS_1 VPW WEN YW0
+  YW1 YW2 YW3 RAMSP1024X16FLCOLM4_BIST_WM
XIO_CORNER VDDC VNWC VDDPE VPW VPW RAMSP1024X16CCHD4_CORNER
.ENDS RAMSP1024X16IOEDGE
****
.SUBCKT RAMSP1024X16RDM4 D DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L DUM_SEL_TD_R
+  DUM_SI DUM_SO DWL_L DWL_R Q SAO TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN
+  WENY
** RAMSP1024X16RDM4: 2 flat devices **
X_MI149.MXNA1 Q SAO VSS VPW N11LL_CKT W=2.01U L=0.04U
X_MI149.MXPA1 Q SAO VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
.ENDS RAMSP1024X16RDM4
****
.SUBCKT RAMSP1024X16IO_RDM_L DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L
+  DUM_SEL_TD_R DUM_SI DUM_SO DWL_L DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0
+  Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7
+  TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4
+  TWEN_5 TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1
+  VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSS WENY_0 WENY_1 WENY_2 WENY_3 WENY_4
+  WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMSP1024X16IO_RDM_L: 16 flat devices **
XL_RDM_1 D_1 DUM_SEL_SI_R_0 DUM_SEL_SI_R_8 DUM_SEL_TD_R_2 DUM_SEL_TD_R_10
+  DUM_SI_12 DUM_SI_4 DWL_R_6 DWL_R_14 Q_1 SAO_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1
+  VNWP_1 VPW_1 VSS VSS WEN_1 WENY_1 RAMSP1024X16RDM4
XL_RDM_2 D_2 DUM_SEL_SI_R_8 DUM_SEL_SI_R_24 DUM_SEL_TD_R_10 DUM_SEL_TD_R_26
+  DUM_SI_28 DUM_SI_12 DWL_R_14 DWL_R_30 Q_2 SAO_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2
+  VNWP_2 VPW_2 VSS VSS WEN_2 WENY_2 RAMSP1024X16RDM4
XL_RDM_3 D_3 DUM_SEL_SI_R_24 DUM_SEL_SI_R_32 DUM_SEL_TD_R_26 DUM_SEL_TD_R_34
+  DUM_SI_36 DUM_SI_28 DWL_R_30 DWL_R_38 Q_3 SAO_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3
+  VNWP_3 VPW_3 VSS VSS WEN_3 WENY_3 RAMSP1024X16RDM4
XL_RDM_4 D_4 DUM_SEL_SI_R_32 DUM_SEL_SI_R_40 DUM_SEL_TD_R_34 DUM_SEL_TD_R_42
+  DUM_SI_44 DUM_SI_36 DWL_R_38 DWL_R_46 Q_4 SAO_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4
+  VNWP_4 VPW_4 VSS VSS WEN_4 WENY_4 RAMSP1024X16RDM4
XL_RDM_5 D_5 DUM_SEL_SI_R_40 DUM_SEL_SI_R_48 DUM_SEL_TD_R_42 DUM_SEL_TD_R_50
+  DUM_SI_52 DUM_SI_44 DWL_R_46 DWL_R_54 Q_5 SAO_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5
+  VNWP_5 VPW_5 VSS VSS WEN_5 WENY_5 RAMSP1024X16RDM4
XL_RDM_6 D_6 DUM_SEL_SI_R_48 DUM_SEL_SI_L_16 DUM_SEL_TD_R_50 DUM_SEL_TD_L_18
+  DUM_SO_20 DUM_SI_52 DWL_R_54 DWL_L_22 Q_6 SAO_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6
+  VNWP_6 VPW_6 VSS VSS WEN_6 WENY_6 RAMSP1024X16RDM4
XL_RDM_L D_0 DUM_SEL_SI_L DUM_SEL_SI_R_0 DUM_SEL_TD_L DUM_SEL_TD_R_2 DUM_SI_4
+  DUM_SO DWL_L DWL_R_6 Q_0 SAO_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0 VSS
+  VSS WEN_0 WENY_0 RAMSP1024X16RDM4
XL_RDM_R D_7 DUM_SEL_SI_L_16 DUM_SEL_SI_R DUM_SEL_TD_L_18 DUM_SEL_TD_R DUM_SI
+  DUM_SO_20 DWL_L_22 DWL_R Q_7 SAO_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7 VNWP_7 VPW_7
+  VSS VSS WEN_7 WENY_7 RAMSP1024X16RDM4
.ENDS RAMSP1024X16IO_RDM_L
****
.SUBCKT RAMSP1024X16CCHD4_TOPBOT BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** RAMSP1024X16CCHD4_TOPBOT: 32 flat devices **
X_MXN16 VSSE NET150 NET93 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN17 NBL[2] VPW NET97 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN18 NET88 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN19 VPW VPW NET45 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN20 NET80 NET154 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN21 VPW NET146 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN22 VPW NET114 NET61 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN23 VPW NET158 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN24 NET84 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN25 VPW NET142 NET57 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN26 VPW NET138 NET49 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN27 NET64 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN28 VPW NET130 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN29 VPW NET126 NET37 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN30 VPW NET134 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN31 NET32 NET118 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN32 VPW VPW NET41 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN33 NET104 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN34 NBL[0] VPW NET101 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN35 VSSE NET122 NET73 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET149 NET150 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 VDDC NET154 NET151 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 VNWC NET158 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 NET113 NET114 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET141 NET142 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 VNWC NET146 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP20 VNWC NET134 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP21 NET137 NET138 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP22 NET125 NET126 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP23 VNWC NET130 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP24 VDDC NET118 NET115 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP25 NET121 NET122 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMSP1024X16CCHD4_TOPBOT
****
.SUBCKT RAMSP1024X16IOTOPCAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW
** RAMSP1024X16IOTOPCAP_L: 256 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
.ENDS RAMSP1024X16IOTOPCAP_L
****
.SUBCKT RAMSP1024X16IO_ROW_L BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  DFTRAMBYP DUMMY_DWL_R DUM_SEL_D_R DUM_SEL_SI_R_0 DUM_SEL_SI_R_1
+  DUM_SEL_TD_R_0 DUM_SEL_TD_R_1 DUM_SI DUM_SO DWL DWL_R D_0 D_1 D_2 D_3 D_4
+  D_5 D_6 D_7 LOG0_0 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3
+  Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SO TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4
+  TWEN_5 TWEN_6 TWEN_7 VDDCE VDDPE VSS WENR WENY_0 WENY_1 WENY_2 WENY_3
+  WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  YW0 YW1 YW2 YW3
** RAMSP1024X16IO_ROW_L: 1565 flat devices **
XIO_CDM_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BLPRECH DFTRAMBYP
+  DUMMY_DWL_L DUMMY_DWL_R DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R_1
+  DUM_SEL_TD_L DUM_SEL_TD_R_1 DUM_SI_8 DUM_SO DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6
+  D_7 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5
+  NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5
+  NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_0 SAO_1 SAO_2
+  SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 SO TD_0
+  TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2
+  TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDPE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VSS
+  WENL WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0
+  WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
+  RAMSP1024X16IOCDM_L
XIO_EDGE_L BLPRECH DFTRAMBYP DUMMY_DWL_L DUM_SEL_D_L DUM_SEL_SI_0 DUM_SEL_SI_L
+  DUM_SEL_TD_0 DUM_SEL_TD_L DUM_SI_0 DUM_SI_8 DWL LOG0_1 NACT_CC NSAE NWCLK
+  NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL
+  VDDCE VDDCE VDDPE VDDCE VSS VSS VSS WENL YW0 YW1 YW2 YW3 RAMSP1024X16IOEDGE
XIO_RDM_ROW_L DUM_SEL_SI_0 DUM_SEL_SI_R_0 DUM_SEL_TD_0 DUM_SEL_TD_R_0 DUM_SI
+  DUM_SI_0 DWL DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5
+  Q_6 Q_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3
+  TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5
+  WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  RAMSP1024X16IO_RDM_L
XIO_TOPCAP_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDCE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VSS RAMSP1024X16IOTOPCAP_L
.ENDS RAMSP1024X16IO_ROW_L
****
.SUBCKT RAMSP1024X16CKM4_BIST ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1
+  CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAMBYP DFTRAM_RET DUMMY_DWL_L
+  DUMMY_DWL_R DUMMY_WL DUM_NWCLK DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0
+  DUM_PSO1 DUM_TPEN DWL DWL_WDX EMAW[0] EMAW[1] EMA[0] EMA[1] EMA[2] FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP IRA_P2[5] LA0 LA1 LA2 LAY0
+  LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE
+  NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 RA0 RA1 RA2
+  RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2]
+  RA_P2[3] RA_P2[4] RA_P2[5] RDT RET RET1N SAE_DUMMY SAPRECH SE SEL_D SEL_SI
+  SEL_TD SO0 SO1 TCA0 TCA1 TCA2 TCEN TE TEN TGWEN TLA0 TLA1 TLA2 TRA0 TRA1
+  TRA2 TRA3 TRA4 TRA5 VDDCE VDDC_L VDDC_LEFT VDDC_R VDDC_RIGHT VDDP VDDPE
+  VDDP_CLKGEN VNWC VNWP VPW VSS VSSE WR_THRU YW0 YW1 YW2 YW3
** RAMSP1024X16CKM4_BIST: 777 flat devices **
X_MI0.MXNA1 NET0571 RET1N I0.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXNA2 I0.N1 WEMA00_N VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXPA1 NET0571 RET1N VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI0.MXPA2 NET0571 WEMA00_N VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI1.MXNA1 INSAE GTPSA_SPLIT I1.N1 VPW N11LL_CKT W=0.565U L=0.04U
X_MI1.MXNA2 I1.N1 NGWE_DFT VSS VPW N11LL_CKT W=0.565U L=0.04U
X_MI1.MXPA1 INSAE GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.515U L=0.04U
X_MI1.MXPA2 INSAE NGWE_DFT VDDPE VNWP P11LL_CKT W=0.515U L=0.04U
X_MI102.MXNA1 NTE TE VSS VPW N11LL_CKT W=1.83U L=0.04U
X_MI102.MXPA1 NTE TE VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MI107.I2.MXNA1 SEL_SI I107.NSE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I2.MXPA1 SEL_SI I107.NSE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I4.MXNA1 SEL_TD I107.NET18 VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I4.MXPA1 SEL_TD I107.NET18 VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I5.MXNA1 SEL_D I107.TE VSS VPW N11LL_CKT W=1.4U L=0.04U
X_MI107.I5.MXPA1 SEL_D I107.TE VDDPE VNWP P11LL_CKT W=2.85U L=0.04U
X_MI107.I7.MXNA1 I107.NSE SE VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI107.I7.MXPA1 I107.NSE SE VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI107.I8.MXNA1 I107.NET18 I107.NSE I107.I8.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXNA2 I107.I8.N1 I107.TE VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA1 I107.NET18 I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I8.MXPA2 I107.NET18 I107.TE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA1 I107.TE I107.NSE I107.I83.N1 VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXNA2 I107.I83.N1 TEN VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA1 I107.TE I107.NSE VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI107.I83.MXPA2 I107.TE TEN VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI116_0.MXNA1 SO0 NET519[1] VSS VPW N11LL_CKT W=0.56U L=0.04U
X_MI116_0.MXPA1 SO0 NET519[1] VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MI116_1.MXNA1 SO1 NET519[0] VSS VPW N11LL_CKT W=0.56U L=0.04U
X_MI116_1.MXPA1 SO1 NET519[0] VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MI117.MXNA1 IDFTRAMBYP NDFTRAMBYP VSS VPW N11LL_CKT W=1.065U L=0.04U
X_MI117.MXPA1 IDFTRAMBYP NDFTRAMBYP VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MI118.MXNA1 NDFTRAMBYP DFTRAMBYP VSS VPW N11LL_CKT W=0.28U L=0.04U
X_MI118.MXPA1 NDFTRAMBYP DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI12.MXNA1 NDY CEN_P2 I12.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXNA2 I12.N1 IDFTRAMBYP VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA1 NDY CEN_P2 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI12.MXPA2 NDY IDFTRAMBYP VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI123.MXNA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI123.MXPA1 NDFTRAMBYP_LAT DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MI130_0.MXNA1 I130_0.N1 CA_P2[0] VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_0.MXNOE NCADDR0 CA_P2[0] I130_0.N1 VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_0.MXPA1 I130_0.P1 CA_P2[0] VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI130_0.MXPOEN NCADDR0 CA_P2[0] I130_0.P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MI130_1.MXNA1 I130_1.N1 CA_P2[1] VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_1.MXNOE NCADDR1 CA_P2[1] I130_1.N1 VPW N11LL_CKT W=0.355U L=0.04U
X_MI130_1.MXPA1 I130_1.P1 CA_P2[1] VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI130_1.MXPOEN NCADDR1 CA_P2[1] I130_1.P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MI131.MXNA1 RET1N_WEMA00N NET0571 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI131.MXPA1 RET1N_WEMA00N NET0571 VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI133_0.MXNA1 CADDR0 NCADDR0 VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI133_0.MXPA1 CADDR0 NCADDR0 VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI133_1.MXNA1 CADDR1 NCADDR1 VSS VPW N11LL_CKT W=0.355U L=0.04U
X_MI133_1.MXPA1 CADDR1 NCADDR1 VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MI134.MXNA1 NET0586 RET1N I134.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXNA2 I134.N1 NDFTRAMBYP_LAT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA1 NET0586 RET1N VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI134.MXPA2 NET0586 NDFTRAMBYP_LAT VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI135.MXNA1 NGWE_DFT GWE_P2 VSS VPW N11LL_CKT W=0.44U L=0.04U
X_MI135.MXNA2 NGWE_DFT IDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.44U L=0.04U
X_MI135.MXPA1 NGWE_DFT GWE_P2 I135.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_MI135.MXPA2 I135.P1 IDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI138.MXNA1 RET RET1N VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI138.MXPA1 RET RET1N VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI149.MXNA1 NRDT_RD GWEN_P2 I149.N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MI149.MXNA2 I149.N2 RET1N I149.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MI149.MXNA3 I149.N1 RDT_P2 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI149.MXPA1 NRDT_RD GWEN_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI149.MXPA2 NRDT_RD RET1N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI149.MXPA3 NRDT_RD RDT_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI152.MXNA1 GWEN_P2 GWE_P2 VSS VPW N11LL_CKT W=0.59U L=0.04U
X_MI152.MXPA1 GWEN_P2 GWE_P2 VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MI1521.MXNA1 CEN_P2 NET0415 VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MI1521.MXPA1 CEN_P2 NET0415 VDDPE VNWP P11LL_CKT W=1.275U L=0.04U
X_MI153.MXNA1 GWE_P2 GWEN_LAT_Q VSS VPW N11LL_CKT W=0.75U L=0.04U
X_MI153.MXPA1 GWE_P2 GWEN_LAT_Q VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MI154.MXNA1 RDT_RD NRDT_RD VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_MI154.MXPA1 RDT_RD NRDT_RD VDDPE VNWP P11LL_CKT W=0.79U L=0.04U
X_MI155_0.MXNA1 NET519[1] NSAO_L VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI155_0.MXPA1 NET519[1] NSAO_L VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI155_1.MXNA1 NET519[0] NSAO_R VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI155_1.MXPA1 NET519[0] NSAO_R VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXN0 I156.NET104 I156.NET116 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN1 I156.NET135 DWL_WDX VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN2 I156.NET112 I156.NET135 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN3 VSS I156.NET104 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN4 I156.NET116 I156.NET135 I156.NET112 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MI156.MXN8 DWL_DLY I156.NET104 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXP0 DWL_DLY I156.NET104 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI156.MXP1 I156.NET123 I156.NET116 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI156.MXP2 I156.NET104 I156.NET116 I156.NET123 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_MI156.MXP3 I156.NET135 DWL_WDX VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI156.MXP5 I156.NET116 I156.NET135 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI169.MXNA1 NET007 GTP VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI169.MXNA2 NET007 GTPSA_SPLIT VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI169.MXPA1 NET007 GTP I169.P1 VNWP P11LL_CKT W=0.6U L=0.04U
X_MI169.MXPA2 I169.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI176.MXNA1 ISAPRECH GTP VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI176.MXNA2 ISAPRECH GTPSA_SPLIT VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI176.MXPA1 ISAPRECH GTP I176.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_MI176.MXPA2 I176.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI178.MXNA1 IDFTRAMBYP_LAT NDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.21U L=0.04U
X_MI178.MXPA1 IDFTRAMBYP_LAT NDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MI179.MXNA1 INSAE_DLY NET0694 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI179.MXPA1 INSAE_DLY NET0694 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI180.MXNA1 NET0694 INSAE VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI180.MXPA1 NET0694 INSAE VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI182.MXNA1 DFTRAM_NRET NET0586 VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI182.MXPA1 DFTRAM_NRET NET0586 VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI183.MXNA1 WEMA00 EMAW[0] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI183.MXNA2 WEMA00 EMAW[1] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI183.MXPA1 WEMA00 EMAW[0] I183.P1 VNWP P11LL_CKT W=0.17U L=0.04U
X_MI183.MXPA2 I183.P1 EMAW[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI184.MXNA1 WEMA00_N WEMA00 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI184.MXPA1 WEMA00_N WEMA00 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI237.MXNA1 NCLK_GTPSA BCLK_GTPSA VSS VPW N11LL_CKT W=0.2U L=0.04U
X_MI237.MXPA1 NCLK_GTPSA BCLK_GTPSA VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI32.MXNA1 NCLK GTP VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI32.MXPA1 NCLK GTP VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI4.MXNA1 NICLK GTP VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI4.MXPA1 NICLK GTP VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MI5.MXNA1 BCLK NICLK VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI5.MXPA1 BCLK NICLK VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI50.MXNA1 IWCLK_WT INWCLK_WT VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MI50.MXPA1 IWCLK_WT INWCLK_WT VDDPE VNWP P11LL_CKT W=2.1U L=0.04U
X_MI52.MXNA1 DFTRAM_RET DFTRAM_NRET VSSE VPW N11LL_CKT W=3.55U L=0.04U
X_MI52.MXPA1 DFTRAM_RET DFTRAM_NRET VDDCE VNWC P11LL_CKT W=7.1U L=0.04U
X_MI62.MXNA1 CENY NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI62.MXPA1 CENY NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MI64.MXNA1 NSAPRECH ISAPRECH VSS VPW N11LL_CKT W=1.41U L=0.04U
X_MI64.MXPA1 NSAPRECH ISAPRECH VDDPE VNWP P11LL_CKT W=2.835U L=0.04U
X_MI78.I51.MXNA1 I78.DGTP_L I78.IGTP VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I51.MXNA2 I78.DGTP_L I78.DRET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I51.MXPA1 I78.DGTP_L I78.IGTP I78.I51.P1 VNWP P11LL_CKT W=0.35U L=0.04U
X_MI78.I51.MXPA2 I78.I51.P1 I78.DRET VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_MI78.I52.MXNA1 I78.DGTP_R I78.IGTP VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I52.MXNA2 I78.DGTP_R RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I52.MXPA1 I78.DGTP_R I78.IGTP I78.I52.P1 VNWP P11LL_CKT W=0.35U L=0.04U
X_MI78.I52.MXPA2 I78.I52.P1 RET VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_MI78.I64.MXNA1 I78.I64.N1 I78.NET039 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI78.I64.MXNOE I78.NET047 I78.NET039 I78.I64.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_MI78.I64.MXPA1 I78.I64.P1 I78.NET039 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I64.MXPOEN I78.NET047 I78.NET039 I78.I64.P1 VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I65.MXNA1 I78.I65.N1 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I65.MXNOE I78.NET039 RET I78.I65.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I65.MXPA1 I78.I65.P1 RET VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_MI78.I65.MXPOEN I78.NET039 RET I78.I65.P1 VNWP P11LL_CKT W=0.43U L=0.04U
X_MI78.I68.MXNA1 I78.DRET I78.NET49 VSSE VPW N11LL_CKT W=0.17U L=0.04U
X_MI78.I68.MXPA1 I78.DRET I78.NET49 VDDPE VNWP P11LL_CKT W=0.345U L=0.04U
X_MI78.I69.MXNA1 I78.NET49 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I69.MXNA2 I78.NET49 I78.NET047 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI78.I69.MXPA1 I78.NET49 RET I78.I69.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_MI78.I69.MXPA2 I78.I69.P1 I78.NET047 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI78.MXN0 BLPRECH_R I78.NBLPRECH_R VSSE VPW N11LL_CKT W=4.06U L=0.04U
X_MI78.MXN1 BLPRECH_L I78.NBLPRECH_L VSSE VPW N11LL_CKT W=4.06U L=0.04U
X_MI78.MXN2 I78.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_MI78.MXN4 I78.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_MI78.MXP0 VDDPE RDT_RD VDDPE VNWP P11LL_CKT W=4.095U L=0.04U
X_MI78.MXP2 BLPRECH_R I78.NBLPRECH_R VDDPE VNWP P11LL_CKT W=5.54U L=0.04U
X_MI78.MXP3 BLPRECH_L I78.NBLPRECH_L VDDPE VNWP P11LL_CKT W=5.54U L=0.04U
X_MI78.MXP4 I78.IGTP NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI78._aoi_bl_f.MXN0 I78.NBLPRECH_L NGTP I78._AOI_BL_F.NET12 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_MI78._aoi_bl_f.MXN1 I78._AOI_BL_F.NET12 I78.DGTP_L VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_MI78._aoi_bl_f.MXN2 I78.NBLPRECH_L RDT_RD VSS VPW N11LL_CKT W=0.34U L=0.04U
X_MI78._aoi_bl_f.MXP0 I78.NBLPRECH_L NGTP VDDPE VNWP P11LL_CKT W=1.365U
+  L=0.04U
X_MI78._aoi_bl_f.MXP1 I78.NBLPRECH_L I78.DGTP_L VDDPE VNWP P11LL_CKT W=1.365U
+  L=0.04U
X_MI78._aoi_bl_r.MXN0 I78.NBLPRECH_R NGTP I78._AOI_BL_R.NET12 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_MI78._aoi_bl_r.MXN1 I78._AOI_BL_R.NET12 I78.DGTP_R VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_MI78._aoi_bl_r.MXN2 I78.NBLPRECH_R RDT_RD VSS VPW N11LL_CKT W=0.34U L=0.04U
X_MI78._aoi_bl_r.MXP0 I78.NBLPRECH_R NGTP VDDPE VNWP P11LL_CKT W=1.365U
+  L=0.04U
X_MI78._aoi_bl_r.MXP1 I78.NBLPRECH_R I78.DGTP_R VDDPE VNWP P11LL_CKT W=1.365U
+  L=0.04U
X_MI84.MXNA1 NWCLK_WT IWCLK_WT VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MI84.MXPA1 NWCLK_WT IWCLK_WT VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MI89.MXNA1 NGTP GTP VSS VPW N11LL_CKT W=0.855U L=0.04U
X_MI89.MXPA1 NGTP GTP VDDPE VNWP P11LL_CKT W=0.45U L=0.04U
X_MI91.MXN0 VSSE I91.NET19 I91.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN2 VPW I91.NET15 I91.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN3 VPW I91.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI96.MXN0 VSSE I96.NET19 I96.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI96.MXN2 VPW I96.NET15 I96.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI96.MXN3 VPW I96.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI97.MXNA1 TE TEN VSS VPW N11LL_CKT W=1.68U L=0.04U
X_MI97.MXPA1 TE TEN VDDPE VNWP P11LL_CKT W=3.42U L=0.04U
X_MXN0 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN1 NET0415 TCEN N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN10 NSAE SAE VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN18 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN19 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.31U L=0.085U
X_MXN2 NET0415 CEN N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MXN21 NET_0553 WRITE_NGTP VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MXN22 NET_0549 WRITE_NGTP VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MXN23 BCLK_GTPSA NET007 NET_0549 VPW N11LL_CKT W=0.3U L=0.04U
X_MXN3 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.31U L=0.085U
X_MXN4 SAE INSAE NET0537 VPW N11LL_CKT W=0.925U L=0.04U
X_MXN5 N1 NTE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN6 N2 TE VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MXN7 BCLK_GTPSA NET007 NET_0553 VPW N11LL_CKT W=0.3U L=0.04U
X_MXN8 SAPRECH NSAPRECH VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN9 NET0537 INSAE_DLY VSS VPW N11LL_CKT W=0.925U L=0.04U
X_MXP0 NSAE SAE VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_MXP1 NET0415 CEN P1 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP17 BCLK_GTPSA NET007 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MXP18 BCLK_GTPSA WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MXP2 SAE INSAE_DLY VDDPE VNWP P11LL_CKT W=1.705U L=0.04U
X_MXP3 NET0415 TCEN P2 VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP4 P1 TE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP5 P2 NTE VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MXP6 SAE INSAE VDDPE VNWP P11LL_CKT W=1.705U L=0.04U
X_MXP7 SAPRECH NSAPRECH VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY _ADDR_LAT_0._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXNA2 _ADDR_LAT_0._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA1 _ADDR_LAT_0._ADDR_LAT.NDY
+  _ADDR_LAT_0._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I0.MXPA2 _ADDR_LAT_0._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXNA1 CA_P2[0] NCA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_0._addr_lat.I50.MXPA1 CA_P2[0] NCA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNA1 _ADDR_LAT_0._ADDR_LAT.I55.N1 CA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXNOE NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPA1 _ADDR_LAT_0._ADDR_LAT.I55.P1 CA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I55.MXPOEN NCA_P2[0] NCLK
+  _ADDR_LAT_0._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXNA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_0._addr_lat.I62.MXPA1 CAY0 _ADDR_LAT_0._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXNA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_0._addr_lat.I63.MXPA1 _ADDR_LAT_0._ADDR_LAT.IDY
+  _ADDR_LAT_0._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXNOE NCA_P2[0] NCLK _ADDR_LAT_0._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.I65.MXPOEN NCA_P2[0] BCLK _ADDR_LAT_0._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0._addr_lat.MXN1 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN2 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN5 _ADDR_LAT_0._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXN6 _ADDR_LAT_0._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_0._addr_lat.MXP1 _ADDR_LAT_0._ADDR_LAT.ND CA0
+  _ADDR_LAT_0._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP3 _ADDR_LAT_0._ADDR_LAT.ND TCA0
+  _ADDR_LAT_0._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP4 _ADDR_LAT_0._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_0._addr_lat.MXP5 _ADDR_LAT_0._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY _ADDR_LAT_1._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXNA2 _ADDR_LAT_1._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA1 _ADDR_LAT_1._ADDR_LAT.NDY
+  _ADDR_LAT_1._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I0.MXPA2 _ADDR_LAT_1._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXNA1 CA_P2[1] NCA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_1._addr_lat.I50.MXPA1 CA_P2[1] NCA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNA1 _ADDR_LAT_1._ADDR_LAT.I55.N1 CA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXNOE NCA_P2[1] BCLK _ADDR_LAT_1._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPA1 _ADDR_LAT_1._ADDR_LAT.I55.P1 CA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I55.MXPOEN NCA_P2[1] NCLK
+  _ADDR_LAT_1._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXNA1 CAY1 _ADDR_LAT_1._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_1._addr_lat.I62.MXPA1 CAY1 _ADDR_LAT_1._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXNA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_1._addr_lat.I63.MXPA1 _ADDR_LAT_1._ADDR_LAT.IDY
+  _ADDR_LAT_1._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXNOE NCA_P2[1] NCLK _ADDR_LAT_1._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.I65.MXPOEN NCA_P2[1] BCLK _ADDR_LAT_1._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1._addr_lat.MXN1 _ADDR_LAT_1._ADDR_LAT.ND TCA1
+  _ADDR_LAT_1._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN2 _ADDR_LAT_1._ADDR_LAT.ND CA1
+  _ADDR_LAT_1._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN5 _ADDR_LAT_1._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXN6 _ADDR_LAT_1._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_1._addr_lat.MXP1 _ADDR_LAT_1._ADDR_LAT.ND CA1
+  _ADDR_LAT_1._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP3 _ADDR_LAT_1._ADDR_LAT.ND TCA1
+  _ADDR_LAT_1._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP4 _ADDR_LAT_1._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_1._addr_lat.MXP5 _ADDR_LAT_1._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY _ADDR_LAT_2._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXNA2 _ADDR_LAT_2._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA1 _ADDR_LAT_2._ADDR_LAT.NDY
+  _ADDR_LAT_2._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I0.MXPA2 _ADDR_LAT_2._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXNA1 LA_P2[0] NLA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_2._addr_lat.I50.MXPA1 LA_P2[0] NLA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNA1 _ADDR_LAT_2._ADDR_LAT.I55.N1 LA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXNOE NLA_P2[0] BCLK _ADDR_LAT_2._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPA1 _ADDR_LAT_2._ADDR_LAT.I55.P1 LA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I55.MXPOEN NLA_P2[0] NCLK
+  _ADDR_LAT_2._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXNA1 LAY0 _ADDR_LAT_2._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_2._addr_lat.I62.MXPA1 LAY0 _ADDR_LAT_2._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXNA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_2._addr_lat.I63.MXPA1 _ADDR_LAT_2._ADDR_LAT.IDY
+  _ADDR_LAT_2._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXNOE NLA_P2[0] NCLK _ADDR_LAT_2._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.I65.MXPOEN NLA_P2[0] BCLK _ADDR_LAT_2._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2._addr_lat.MXN1 _ADDR_LAT_2._ADDR_LAT.ND TLA0
+  _ADDR_LAT_2._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN2 _ADDR_LAT_2._ADDR_LAT.ND LA0
+  _ADDR_LAT_2._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN5 _ADDR_LAT_2._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXN6 _ADDR_LAT_2._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_2._addr_lat.MXP1 _ADDR_LAT_2._ADDR_LAT.ND LA0
+  _ADDR_LAT_2._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP3 _ADDR_LAT_2._ADDR_LAT.ND TLA0
+  _ADDR_LAT_2._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP4 _ADDR_LAT_2._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_2._addr_lat.MXP5 _ADDR_LAT_2._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXNA1 _ADDR_LAT_3._ADDR_LAT.NDY
+  _ADDR_LAT_3._ADDR_LAT.IDY _ADDR_LAT_3._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXNA2 _ADDR_LAT_3._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXPA1 _ADDR_LAT_3._ADDR_LAT.NDY
+  _ADDR_LAT_3._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I0.MXPA2 _ADDR_LAT_3._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I50.MXNA1 RA_P2[0] NRA_P2[0] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_3._addr_lat.I50.MXPA1 RA_P2[0] NRA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXNA1 _ADDR_LAT_3._ADDR_LAT.I55.N1 RA_P2[0] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXNOE NRA_P2[0] BCLK _ADDR_LAT_3._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXPA1 _ADDR_LAT_3._ADDR_LAT.I55.P1 RA_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I55.MXPOEN NRA_P2[0] NCLK
+  _ADDR_LAT_3._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I62.MXNA1 RAY0 _ADDR_LAT_3._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_3._addr_lat.I62.MXPA1 RAY0 _ADDR_LAT_3._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_3._addr_lat.I63.MXNA1 _ADDR_LAT_3._ADDR_LAT.IDY
+  _ADDR_LAT_3._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_3._addr_lat.I63.MXPA1 _ADDR_LAT_3._ADDR_LAT.IDY
+  _ADDR_LAT_3._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_3._addr_lat.I65.MXNOE NRA_P2[0] NCLK _ADDR_LAT_3._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_3._addr_lat.I65.MXPOEN NRA_P2[0] BCLK _ADDR_LAT_3._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_3._addr_lat.MXN1 _ADDR_LAT_3._ADDR_LAT.ND TRA0
+  _ADDR_LAT_3._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN2 _ADDR_LAT_3._ADDR_LAT.ND RA0
+  _ADDR_LAT_3._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN5 _ADDR_LAT_3._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXN6 _ADDR_LAT_3._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_3._addr_lat.MXP1 _ADDR_LAT_3._ADDR_LAT.ND RA0
+  _ADDR_LAT_3._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP3 _ADDR_LAT_3._ADDR_LAT.ND TRA0
+  _ADDR_LAT_3._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP4 _ADDR_LAT_3._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_3._addr_lat.MXP5 _ADDR_LAT_3._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY _ADDR_LAT_4._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXNA2 _ADDR_LAT_4._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA1 _ADDR_LAT_4._ADDR_LAT.NDY
+  _ADDR_LAT_4._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I0.MXPA2 _ADDR_LAT_4._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXNA1 RA_P2[1] NRA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_4._addr_lat.I50.MXPA1 RA_P2[1] NRA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNA1 _ADDR_LAT_4._ADDR_LAT.I55.N1 RA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXNOE NRA_P2[1] BCLK _ADDR_LAT_4._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPA1 _ADDR_LAT_4._ADDR_LAT.I55.P1 RA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I55.MXPOEN NRA_P2[1] NCLK
+  _ADDR_LAT_4._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXNA1 RAY1 _ADDR_LAT_4._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_4._addr_lat.I62.MXPA1 RAY1 _ADDR_LAT_4._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXNA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_4._addr_lat.I63.MXPA1 _ADDR_LAT_4._ADDR_LAT.IDY
+  _ADDR_LAT_4._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXNOE NRA_P2[1] NCLK _ADDR_LAT_4._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.I65.MXPOEN NRA_P2[1] BCLK _ADDR_LAT_4._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4._addr_lat.MXN1 _ADDR_LAT_4._ADDR_LAT.ND TRA1
+  _ADDR_LAT_4._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN2 _ADDR_LAT_4._ADDR_LAT.ND RA1
+  _ADDR_LAT_4._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN5 _ADDR_LAT_4._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXN6 _ADDR_LAT_4._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_4._addr_lat.MXP1 _ADDR_LAT_4._ADDR_LAT.ND RA1
+  _ADDR_LAT_4._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP3 _ADDR_LAT_4._ADDR_LAT.ND TRA1
+  _ADDR_LAT_4._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP4 _ADDR_LAT_4._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_4._addr_lat.MXP5 _ADDR_LAT_4._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY _ADDR_LAT_5._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXNA2 _ADDR_LAT_5._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA1 _ADDR_LAT_5._ADDR_LAT.NDY
+  _ADDR_LAT_5._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I0.MXPA2 _ADDR_LAT_5._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXNA1 RA_P2[2] NRA_P2[2] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_5._addr_lat.I50.MXPA1 RA_P2[2] NRA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNA1 _ADDR_LAT_5._ADDR_LAT.I55.N1 RA_P2[2] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXNOE NRA_P2[2] BCLK _ADDR_LAT_5._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPA1 _ADDR_LAT_5._ADDR_LAT.I55.P1 RA_P2[2] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I55.MXPOEN NRA_P2[2] NCLK
+  _ADDR_LAT_5._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXNA1 RAY2 _ADDR_LAT_5._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_5._addr_lat.I62.MXPA1 RAY2 _ADDR_LAT_5._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXNA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_5._addr_lat.I63.MXPA1 _ADDR_LAT_5._ADDR_LAT.IDY
+  _ADDR_LAT_5._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXNOE NRA_P2[2] NCLK _ADDR_LAT_5._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.I65.MXPOEN NRA_P2[2] BCLK _ADDR_LAT_5._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5._addr_lat.MXN1 _ADDR_LAT_5._ADDR_LAT.ND TRA2
+  _ADDR_LAT_5._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN2 _ADDR_LAT_5._ADDR_LAT.ND RA2
+  _ADDR_LAT_5._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN5 _ADDR_LAT_5._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXN6 _ADDR_LAT_5._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_5._addr_lat.MXP1 _ADDR_LAT_5._ADDR_LAT.ND RA2
+  _ADDR_LAT_5._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP3 _ADDR_LAT_5._ADDR_LAT.ND TRA2
+  _ADDR_LAT_5._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP4 _ADDR_LAT_5._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_5._addr_lat.MXP5 _ADDR_LAT_5._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY _ADDR_LAT_6._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXNA2 _ADDR_LAT_6._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA1 _ADDR_LAT_6._ADDR_LAT.NDY
+  _ADDR_LAT_6._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I0.MXPA2 _ADDR_LAT_6._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXNA1 RA_P2[3] NRA_P2[3] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_6._addr_lat.I50.MXPA1 RA_P2[3] NRA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNA1 _ADDR_LAT_6._ADDR_LAT.I55.N1 RA_P2[3] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXNOE NRA_P2[3] BCLK _ADDR_LAT_6._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPA1 _ADDR_LAT_6._ADDR_LAT.I55.P1 RA_P2[3] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I55.MXPOEN NRA_P2[3] NCLK
+  _ADDR_LAT_6._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXNA1 RAY3 _ADDR_LAT_6._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_6._addr_lat.I62.MXPA1 RAY3 _ADDR_LAT_6._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXNA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_6._addr_lat.I63.MXPA1 _ADDR_LAT_6._ADDR_LAT.IDY
+  _ADDR_LAT_6._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXNOE NRA_P2[3] NCLK _ADDR_LAT_6._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.I65.MXPOEN NRA_P2[3] BCLK _ADDR_LAT_6._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6._addr_lat.MXN1 _ADDR_LAT_6._ADDR_LAT.ND TRA3
+  _ADDR_LAT_6._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN2 _ADDR_LAT_6._ADDR_LAT.ND RA3
+  _ADDR_LAT_6._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN5 _ADDR_LAT_6._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXN6 _ADDR_LAT_6._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_6._addr_lat.MXP1 _ADDR_LAT_6._ADDR_LAT.ND RA3
+  _ADDR_LAT_6._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP3 _ADDR_LAT_6._ADDR_LAT.ND TRA3
+  _ADDR_LAT_6._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP4 _ADDR_LAT_6._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_6._addr_lat.MXP5 _ADDR_LAT_6._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY _ADDR_LAT_7._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXNA2 _ADDR_LAT_7._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA1 _ADDR_LAT_7._ADDR_LAT.NDY
+  _ADDR_LAT_7._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I0.MXPA2 _ADDR_LAT_7._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXNA1 RA_P2[4] NRA_P2[4] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_7._addr_lat.I50.MXPA1 RA_P2[4] NRA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNA1 _ADDR_LAT_7._ADDR_LAT.I55.N1 RA_P2[4] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXNOE NRA_P2[4] BCLK _ADDR_LAT_7._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPA1 _ADDR_LAT_7._ADDR_LAT.I55.P1 RA_P2[4] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I55.MXPOEN NRA_P2[4] NCLK
+  _ADDR_LAT_7._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXNA1 RAY4 _ADDR_LAT_7._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_7._addr_lat.I62.MXPA1 RAY4 _ADDR_LAT_7._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXNA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_7._addr_lat.I63.MXPA1 _ADDR_LAT_7._ADDR_LAT.IDY
+  _ADDR_LAT_7._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXNOE NRA_P2[4] NCLK _ADDR_LAT_7._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.I65.MXPOEN NRA_P2[4] BCLK _ADDR_LAT_7._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7._addr_lat.MXN1 _ADDR_LAT_7._ADDR_LAT.ND TRA4
+  _ADDR_LAT_7._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN2 _ADDR_LAT_7._ADDR_LAT.ND RA4
+  _ADDR_LAT_7._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN5 _ADDR_LAT_7._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXN6 _ADDR_LAT_7._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_7._addr_lat.MXP1 _ADDR_LAT_7._ADDR_LAT.ND RA4
+  _ADDR_LAT_7._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP3 _ADDR_LAT_7._ADDR_LAT.ND TRA4
+  _ADDR_LAT_7._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP4 _ADDR_LAT_7._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_7._addr_lat.MXP5 _ADDR_LAT_7._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY _ADDR_LAT_8._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXNA2 _ADDR_LAT_8._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA1 _ADDR_LAT_8._ADDR_LAT.NDY
+  _ADDR_LAT_8._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I0.MXPA2 _ADDR_LAT_8._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXNA1 IRA_P2[5] NRA_P2[5] VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_addr_lat_8._addr_lat.I50.MXPA1 IRA_P2[5] NRA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNA1 _ADDR_LAT_8._ADDR_LAT.I55.N1 IRA_P2[5] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXNOE NRA_P2[5] BCLK _ADDR_LAT_8._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPA1 _ADDR_LAT_8._ADDR_LAT.I55.P1 IRA_P2[5]
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I55.MXPOEN NRA_P2[5] NCLK
+  _ADDR_LAT_8._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXNA1 RAY5 _ADDR_LAT_8._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_8._addr_lat.I62.MXPA1 RAY5 _ADDR_LAT_8._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXNA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_8._addr_lat.I63.MXPA1 _ADDR_LAT_8._ADDR_LAT.IDY
+  _ADDR_LAT_8._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXNOE NRA_P2[5] NCLK _ADDR_LAT_8._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.I65.MXPOEN NRA_P2[5] BCLK _ADDR_LAT_8._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8._addr_lat.MXN1 _ADDR_LAT_8._ADDR_LAT.ND TRA5
+  _ADDR_LAT_8._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN2 _ADDR_LAT_8._ADDR_LAT.ND RA5
+  _ADDR_LAT_8._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN5 _ADDR_LAT_8._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXN6 _ADDR_LAT_8._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_8._addr_lat.MXP1 _ADDR_LAT_8._ADDR_LAT.ND RA5
+  _ADDR_LAT_8._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP3 _ADDR_LAT_8._ADDR_LAT.ND TRA5
+  _ADDR_LAT_8._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP4 _ADDR_LAT_8._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_8._addr_lat.MXP5 _ADDR_LAT_8._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXNA1 _ADDR_LAT_9._ADDR_LAT.NDY
+  _ADDR_LAT_9._ADDR_LAT.IDY _ADDR_LAT_9._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXNA2 _ADDR_LAT_9._ADDR_LAT.I0.N1 IDFTRAMBYP VSS
+  VPW N11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXPA1 _ADDR_LAT_9._ADDR_LAT.NDY
+  _ADDR_LAT_9._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I0.MXPA2 _ADDR_LAT_9._ADDR_LAT.NDY IDFTRAMBYP VDDPE
+  VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I50.MXNA1 LA_P2[1] NLA_P2[1] VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_addr_lat_9._addr_lat.I50.MXPA1 LA_P2[1] NLA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXNA1 _ADDR_LAT_9._ADDR_LAT.I55.N1 LA_P2[1] VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXNOE NLA_P2[1] BCLK _ADDR_LAT_9._ADDR_LAT.I55.N1
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXPA1 _ADDR_LAT_9._ADDR_LAT.I55.P1 LA_P2[1] VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I55.MXPOEN NLA_P2[1] NCLK
+  _ADDR_LAT_9._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I62.MXNA1 LAY1 _ADDR_LAT_9._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_addr_lat_9._addr_lat.I62.MXPA1 LAY1 _ADDR_LAT_9._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_addr_lat_9._addr_lat.I63.MXNA1 _ADDR_LAT_9._ADDR_LAT.IDY
+  _ADDR_LAT_9._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addr_lat_9._addr_lat.I63.MXPA1 _ADDR_LAT_9._ADDR_LAT.IDY
+  _ADDR_LAT_9._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addr_lat_9._addr_lat.I65.MXNOE NLA_P2[1] NCLK _ADDR_LAT_9._ADDR_LAT.ND VPW
+  N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_9._addr_lat.I65.MXPOEN NLA_P2[1] BCLK _ADDR_LAT_9._ADDR_LAT.ND
+  VNWP P11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_9._addr_lat.MXN1 _ADDR_LAT_9._ADDR_LAT.ND TLA1
+  _ADDR_LAT_9._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN2 _ADDR_LAT_9._ADDR_LAT.ND LA1
+  _ADDR_LAT_9._ADDR_LAT.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN5 _ADDR_LAT_9._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXN6 _ADDR_LAT_9._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_addr_lat_9._addr_lat.MXP1 _ADDR_LAT_9._ADDR_LAT.ND LA1
+  _ADDR_LAT_9._ADDR_LAT.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP3 _ADDR_LAT_9._ADDR_LAT.ND TLA1
+  _ADDR_LAT_9._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP4 _ADDR_LAT_9._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_addr_lat_9._addr_lat.MXP5 _ADDR_LAT_9._ADDR_LAT.P2 NTE VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.I92.MXNA1 DWL _CKGEN.NGTP VSSE VPW N11LL_CKT W=4.26U L=0.04U
X_M_ckgen.I92.MXPA1 DWL _CKGEN.NGTP VDDP_CLKGEN VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckgen.Iema.I0.MXNA1 _CKGEN.IEMA.NGWE GWE_DFT _CKGEN.IEMA.I0.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXNA2 _CKGEN.IEMA.I0.N1 RET1N_WEMA00N VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXPA1 _CKGEN.IEMA.NGWE GWE_DFT VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckgen.Iema.I0.MXPA2 _CKGEN.IEMA.NGWE RET1N_WEMA00N VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I1.MXNA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I1.MXPA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=1.28U L=0.04U
X_M_ckgen.Iema.I2.MXNA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I2.MXPA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_ckgen.Iema.I20.MXNOE _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NRDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I20.MXPOEN _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NRDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXNOE _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NWDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXPOEN _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NWDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I40.MXNA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I40.MXPA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.I49.MXN3 _CKGEN.IEMA.I49.NET057 GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET049 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN4 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN8 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET057 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN9 _CKGEN.IEMA.I49.NET049 GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP0 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP1 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN
+  _CKGEN.IEMA.I49.NET044 VNWP P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP2 _CKGEN.IEMA.I49.NET044 _CKGEN.IEMA.I49.NDIN VDDPE VNWP
+  P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXNA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=1.03U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXPA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN3 _CKGEN.IEMA.IRMUX._RDLY0.NET40
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET045 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN8 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET40 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN9 _CKGEN.IEMA.IRMUX._RDLY0.NET045
+  _CKGEN.IEMA.IRMUX.CKMX1O VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP0 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP2 _CKGEN.IEMA.IRMUX._RDLY0.NET030
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN _CKGEN.IEMA.IRMUX._RDLY0.NET030 VNWP
+  P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN3 _CKGEN.IEMA.IRMUX._RDLY1.NET046
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET038 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN8 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET046 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN9 _CKGEN.IEMA.IRMUX._RDLY1.NET038
+  _CKGEN.IEMA.IRMUX.CKDLY2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP0 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP2 _CKGEN.IEMA.IRMUX._RDLY1.NET030
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN _CKGEN.IEMA.IRMUX._RDLY1.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN3 _CKGEN.IEMA.IRMUX._RDLY2.NET046 SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET038 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN8 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET046 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN9 _CKGEN.IEMA.IRMUX._RDLY2.NET038 SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP0 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP2 _CKGEN.IEMA.IRMUX._RDLY2.NET030
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN _CKGEN.IEMA.IRMUX._RDLY2.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RMX0.I12.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I12.N1
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 EMA[0]
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A1 EMA[0] VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2
+  _CKGEN.IEMA.IRMUX._RMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNB1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.NCK_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA2 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPB1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP
+  _CKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VPW
+  N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXNA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.936U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXPA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXNA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXPA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen.Iema._wdly0.MXN3 _CKGEN.IEMA._WDLY0.NET057 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN4 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXN8 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN9 _CKGEN.IEMA._WDLY0.NET049 _CKGEN.IEMA.WCLK00 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXP0 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXP1 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN
+  _CKGEN.IEMA._WDLY0.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly0.MXP2 _CKGEN.IEMA._WDLY0.NET044 _CKGEN.IEMA._WDLY0.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXN3 _CKGEN.IEMA._WDLY1.NET057 _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN4 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXN8 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN9 _CKGEN.IEMA._WDLY1.NET049 _CKGEN.IEMA.DWCLK10 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXP0 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXP1 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN
+  _CKGEN.IEMA._WDLY1.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXP2 _CKGEN.IEMA._WDLY1.NET044 _CKGEN.IEMA._WDLY1.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXN3 _CKGEN.IEMA._WDLY2.NET057 _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN4 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXN8 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN9 _CKGEN.IEMA._WDLY2.NET049 _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXP0 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXP1 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN
+  _CKGEN.IEMA._WDLY2.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXP2 _CKGEN.IEMA._WDLY2.NET044 _CKGEN.IEMA._WDLY2.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA2 _CKGEN.IEMA._WMX0.I12.N1
+  _CKGEN.IEMA._WMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA2 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA._WMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01
+  _CKGEN.IEMA._WMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA2 _CKGEN.IEMA._WMX0.I13.N1 EMAW[0] VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA2 _CKGEN.IEMA._WMX0.A1 EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA2 _CKGEN.IEMA._WMX0.I18.A1A2 _CKGEN.IEMA._WMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNB1 _CKGEN.IEMA.WDLY _CKGEN.IEMA.NCK_IN VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA2 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A1
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPB1 _CKGEN.IEMA._WMX0.I18.A1A2UP _CKGEN.IEMA.NCK_IN
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXNA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXPA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXNA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXPA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXNA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXPA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXNA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXPA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_IN VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_DLY VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXNA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXPA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen._memgtp.I1.MXNA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK
+  _CKGEN._MEMGTP.I1.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXNA2 _CKGEN._MEMGTP.I1.N1 RET1N VSSE VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXPA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I1.MXPA2 _CKGEN._MEMGTP.C1 RET1N VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I24.MXNA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNA2 _CKGEN._MEMGTP.I24.A1A2 _CKGEN._MEMGTP.NDFT VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNB1 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.C1 VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.I24.MXPA1 _CKGEN._MEMGTP.C2 CEN_P2 _CKGEN._MEMGTP.I24.A1A2UP
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen._memgtp.I24.MXPA2 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.NDFT
+  _CKGEN._MEMGTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen._memgtp.I24.MXPB1 _CKGEN._MEMGTP.I24.A1A2UP _CKGEN._MEMGTP.C1 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen._memgtp.I6.MXNA1 GTP _CKGEN.NGTP VSSE VPW N11LL_CKT W=5.68U L=0.04U
X_M_ckgen._memgtp.I6.MXPA1 GTP _CKGEN.NGTP VDDPE VNWP P11LL_CKT W=11.36U
+  L=0.04U
X_M_ckgen._memgtp.I68.MXNA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen._memgtp.I68.MXPA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VDDPE VNWP
+  P11LL_CKT W=0.72U L=0.04U
X_M_ckgen._memgtp.I7.MXNA1 _CKGEN._MEMGTP.NCLK CLK VSS VPW N11LL_CKT W=4.26U
+  L=0.04U
X_M_ckgen._memgtp.I7.MXPA1 _CKGEN._MEMGTP.NCLK CLK VDDPE VNWP P11LL_CKT
+  W=4.26U L=0.04U
X_M_ckgen._memgtp.I74.MXNA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VSSE VPW
+  N11LL_CKT W=0.31U L=0.04U
X_M_ckgen._memgtp.I74.MXPA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen._memgtp.I82.MXNA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I82.MXPA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_M_ckgen._memgtp.I83.MXNA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2
+  _CKGEN._MEMGTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXNA2 _CKGEN._MEMGTP.I83.N1 _CKGEN.NET035 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXPA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I83.MXPA2 _CKGEN._MEMGTP.C3 _CKGEN.NET035 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I86.MXNA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_ckgen._memgtp.I86.MXPA1 _CKGEN._MEMGTP.NDFT IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_ckgen._memgtp.MXN0 _CKGEN._MEMGTP.NCLK _CKGEN._MEMGTP.CTR _CKGEN.NGTP VPW
+  N11LL_CKT W=4.25U L=0.04U
X_M_ckgen._memgtp.MXN7 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET114
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_ckgen._memgtp.MXN8 _CKGEN._MEMGTP.NET114 _CKGEN.RESET VSSE VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_ckgen._memgtp.MXP1 _CKGEN.NGTP _CKGEN.RESET VDDPE VNWP P11LL_CKT W=4.275U
+  L=0.04U
X_M_ckgen._memgtp.MXP2 _CKGEN._MEMGTP.NET127 _CKGEN._MEMGTP.CTR VDDPE VNWP
+  P11LL_CKT W=0.685U L=0.04U
X_M_ckgen._memgtp.MXP3 _CKGEN._MEMGTP.NET127 CLK VDDPE VNWP P11LL_CKT W=0.685U
+  L=0.04U
X_M_ckgen._memgtp.MXP5 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET127
+  VNWP P11LL_CKT W=0.685U L=0.04U
X_M_dftram_lat.I47.MXNA1 _DFTRAM_LAT.ND IDFTRAMBYP VSS VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_dftram_lat.I47.MXPA1 _DFTRAM_LAT.ND IDFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.68U L=0.04U
X_M_dftram_lat.I48.MXNOE DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.ND VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I48.MXPOEN DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.ND VNWP P11LL_CKT
+  W=0.34U L=0.04U
X_M_dftram_lat.I50.MXNA1 DFTRAMBYP_LAT DFT_LAT_NQ VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_dftram_lat.I50.MXPA1 DFTRAMBYP_LAT DFT_LAT_NQ VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_dftram_lat.I55.MXNA1 _DFTRAM_LAT.I55.N1 DFTRAMBYP_LAT VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXNOE DFT_LAT_NQ BCLK_GTPSA _DFTRAM_LAT.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPA1 _DFTRAM_LAT.I55.P1 DFTRAMBYP_LAT VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_dftram_lat.I55.MXPOEN DFT_LAT_NQ NCLK_GTPSA _DFTRAM_LAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY _GWEN_LAT._ADDR_LAT.I0.N1 VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_gwen_lat._addr_lat.I0.MXNA2 _GWEN_LAT._ADDR_LAT.I0.N1 IDFTRAMBYP VSS VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA1 _GWEN_LAT._ADDR_LAT.NDY
+  _GWEN_LAT._ADDR_LAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I0.MXPA2 _GWEN_LAT._ADDR_LAT.NDY IDFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXNA1 GWEN_LAT_Q GWEN_LAT_NQ VSS VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_gwen_lat._addr_lat.I50.MXPA1 GWEN_LAT_Q GWEN_LAT_NQ VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNA1 _GWEN_LAT._ADDR_LAT.I55.N1 GWEN_LAT_Q VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXNOE GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPA1 _GWEN_LAT._ADDR_LAT.I55.P1 GWEN_LAT_Q VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I55.MXPOEN GWEN_LAT_NQ NCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXNA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VSS VPW
+  N11LL_CKT W=0.5U L=0.04U
X_M_gwen_lat._addr_lat.I62.MXPA1 GWENY _GWEN_LAT._ADDR_LAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.12U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXNA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_gwen_lat._addr_lat.I63.MXPA1 _GWEN_LAT._ADDR_LAT.IDY
+  _GWEN_LAT._ADDR_LAT.ND VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXNOE GWEN_LAT_NQ NCLK_GTPSA _GWEN_LAT._ADDR_LAT.ND
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.I65.MXPOEN GWEN_LAT_NQ BCLK_GTPSA
+  _GWEN_LAT._ADDR_LAT.ND VNWP P11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat._addr_lat.MXN1 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.N2 VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN2 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.N1
+  VPW N11LL_CKT W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN5 _GWEN_LAT._ADDR_LAT.N1 NTE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXN6 _GWEN_LAT._ADDR_LAT.N2 TE VSS VPW N11LL_CKT
+  W=0.35U L=0.04U
X_M_gwen_lat._addr_lat.MXP1 _GWEN_LAT._ADDR_LAT.ND GWEN _GWEN_LAT._ADDR_LAT.P1
+  VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP3 _GWEN_LAT._ADDR_LAT.ND TGWEN
+  _GWEN_LAT._ADDR_LAT.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP4 _GWEN_LAT._ADDR_LAT.P1 TE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_gwen_lat._addr_lat.MXP5 _GWEN_LAT._ADDR_LAT.P2 NTE VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_rdt_lat.I47.MXNA1 _RDT_LAT.ND RDT VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I47.MXPA1 _RDT_LAT.ND RDT VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_M_rdt_lat.I48.MXNOE NRDT_LAT NCLK _RDT_LAT.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I48.MXPOEN NRDT_LAT BCLK _RDT_LAT.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_rdt_lat.I50.MXNA1 RDT_P2 NRDT_LAT VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_rdt_lat.I50.MXPA1 RDT_P2 NRDT_LAT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_rdt_lat.I55.MXNA1 _RDT_LAT.I55.N1 RDT_P2 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_rdt_lat.I55.MXNOE NRDT_LAT BCLK _RDT_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPA1 _RDT_LAT.I55.P1 RDT_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPOEN NRDT_LAT NCLK _RDT_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I14.MXNA1 NWCLK _WRITE.NET0102 VSS VPW N11LL_CKT W=5.54U L=0.04U
X_M_write.I14.MXPA1 NWCLK _WRITE.NET0102 VDDPE VNWP P11LL_CKT W=5.67U L=0.04U
X_M_write.I27.MXNA1 _WRITE.NET0102 _WRITE.NET66 VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_write.I27.MXPA1 _WRITE.NET0102 _WRITE.NET66 VDDPE VNWP P11LL_CKT W=2.13U
+  L=0.04U
X_M_write.I52.MXNA1 INWCLK_WT BCLK _WRITE.I52.N2 VPW N11LL_CKT W=0.73U L=0.04U
X_M_write.I52.MXNA2 _WRITE.I52.N2 GWE_DFT _WRITE.I52.N1 VPW N11LL_CKT W=0.73U
+  L=0.04U
X_M_write.I52.MXNA3 _WRITE.I52.N1 _WRITE.NET076 VSS VPW N11LL_CKT W=0.73U
+  L=0.04U
X_M_write.I52.MXPA1 INWCLK_WT BCLK VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_M_write.I52.MXPA2 INWCLK_WT GWE_DFT VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_M_write.I52.MXPA3 INWCLK_WT _WRITE.NET076 VDDPE VNWP P11LL_CKT W=0.35U
+  L=0.04U
X_M_write.I53.MXNA1 _WRITE.NET66 GTP _WRITE.I53.NET39 VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXNA2 _WRITE.NET66 _WRITE.DGTP _WRITE.I53.NET39 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_write.I53.MXNB1 _WRITE.I53.NET39 GWE_DFT VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXPA1 _WRITE.NET66 GTP _WRITE.I53.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPA2 _WRITE.I53.P1 _WRITE.DGTP VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPB1 _WRITE.NET66 GWE_DFT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_write.I61.MXNA1 _WRITE.NET035 WR_THRU VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_write.I61.MXNA2 _WRITE.NET035 IDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I61.MXPA1 _WRITE.NET035 WR_THRU _WRITE.I61.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I61.MXPA2 _WRITE.I61.P1 IDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I62.MXNA1 _WRITE.NET076 _WRITE.NET035 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I62.MXPA1 _WRITE.NET076 _WRITE.NET035 VDDPE VNWP P11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I64.MXNA1 GWE_DFT NGWE_DFT VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_write.I64.MXPA1 GWE_DFT NGWE_DFT VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_write.MXN0 WRITE_NGTP DWL_DLY VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN3 _WRITE.NET037 WRITE_NGTP VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN8 _WRITE.DGTP WRITE_NGTP _WRITE.NET037 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_write.MXP0 _WRITE.DGTP WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP1 VDDPE DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP2 WRITE_NGTP DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ydec.I10_0.MXNA1 _YDEC.YSEL[0] CADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_0.MXNA2 _YDEC.YSEL[0] CADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_0.MXPA1 _YDEC.YSEL[0] CADDR1 _YDEC.I10_0.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_0.MXPA2 _YDEC.I10_0.P1 CADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_1.MXNA1 _YDEC.YSEL[1] CADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_1.MXNA2 _YDEC.YSEL[1] NCADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_1.MXPA1 _YDEC.YSEL[1] CADDR1 _YDEC.I10_1.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_1.MXPA2 _YDEC.I10_1.P1 NCADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_2.MXNA1 _YDEC.YSEL[2] NCADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_2.MXNA2 _YDEC.YSEL[2] CADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_2.MXPA1 _YDEC.YSEL[2] NCADDR1 _YDEC.I10_2.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_2.MXPA2 _YDEC.I10_2.P1 CADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I10_3.MXNA1 _YDEC.YSEL[3] NCADDR1 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_3.MXNA2 _YDEC.YSEL[3] NCADDR0 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ydec.I10_3.MXPA1 _YDEC.YSEL[3] NCADDR1 _YDEC.I10_3.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_ydec.I10_3.MXPA2 _YDEC.I10_3.P1 NCADDR0 VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA1 _YDEC.NGTP_DFT GTP _YDEC.I13.N1 VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA2 _YDEC.I13.N1 NDFTRAMBYP_LAT VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXPA1 _YDEC.NGTP_DFT GTP VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_M_ydec.I13.MXPA2 _YDEC.NGTP_DFT NDFTRAMBYP_LAT VDDPE VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA1 _YDEC.CLK_WR _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA2 _YDEC.CLK_WR NGWE VSSE VPW N11LL_CKT W=0.71U L=0.04U
X_M_ydec.I7.MXPA1 _YDEC.CLK_WR _YDEC.NGTP_DFT _YDEC.I7.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I7.MXPA2 _YDEC.I7.P1 NGWE VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I8.MXNA1 _YDEC.CLK_RD _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_ydec.I8.MXNA2 _YDEC.CLK_RD GWE_P2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ydec.I8.MXPA1 _YDEC.CLK_RD _YDEC.NGTP_DFT _YDEC.I8.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I8.MXPA2 _YDEC.I8.P1 GWE_P2 VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I9.MXNA1 NGWE GWE_P2 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ydec.I9.MXPA1 NGWE GWE_P2 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ydec._rmux_0.I39.MXNA1 NYR0 _YDEC._RMUX_0.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_0.I39.MXPA1 NYR0 _YDEC._RMUX_0.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_0.MXN0 _YDEC._RMUX_0.INYP _YDEC.YSEL[0] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_0.MXN1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_0.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_0.MXP0 _YDEC._RMUX_0.INYP _YDEC.YSEL[0] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_0.MXP1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_0.MXP2 _YDEC._RMUX_0.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.I39.MXNA1 NYR1 _YDEC._RMUX_1.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_1.I39.MXPA1 NYR1 _YDEC._RMUX_1.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_1.MXN0 _YDEC._RMUX_1.INYP _YDEC.YSEL[1] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_1.MXN1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_1.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_1.MXP0 _YDEC._RMUX_1.INYP _YDEC.YSEL[1] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.MXP1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_1.MXP2 _YDEC._RMUX_1.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_2.I39.MXNA1 NYR2 _YDEC._RMUX_2.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_2.I39.MXPA1 NYR2 _YDEC._RMUX_2.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_2.MXN0 _YDEC._RMUX_2.INYP _YDEC.YSEL[2] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_2.MXN1 _YDEC._RMUX_2.IYP _YDEC._RMUX_2.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_2.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_2.MXP0 _YDEC._RMUX_2.INYP _YDEC.YSEL[2] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_2.MXP1 _YDEC._RMUX_2.IYP _YDEC._RMUX_2.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_2.MXP2 _YDEC._RMUX_2.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_3.I39.MXNA1 NYR3 _YDEC._RMUX_3.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_3.I39.MXPA1 NYR3 _YDEC._RMUX_3.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_3.MXN0 _YDEC._RMUX_3.INYP _YDEC.YSEL[3] _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_3.MXN1 _YDEC._RMUX_3.IYP _YDEC._RMUX_3.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_3.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_3.MXP0 _YDEC._RMUX_3.INYP _YDEC.YSEL[3] VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_3.MXP1 _YDEC._RMUX_3.IYP _YDEC._RMUX_3.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_3.MXP2 _YDEC._RMUX_3.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._wmux_0.MXN0 _YDEC._WMUX_0.INYP _YDEC.YSEL[0] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_0.MXN1 YW0 _YDEC._WMUX_0.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_0.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_0.MXP0 _YDEC._WMUX_0.INYP _YDEC.YSEL[0] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_0.MXP1 YW0 _YDEC._WMUX_0.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_0.MXP2 _YDEC._WMUX_0.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_1.MXN0 _YDEC._WMUX_1.INYP _YDEC.YSEL[1] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_1.MXN1 YW1 _YDEC._WMUX_1.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_1.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_1.MXP0 _YDEC._WMUX_1.INYP _YDEC.YSEL[1] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_1.MXP1 YW1 _YDEC._WMUX_1.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_1.MXP2 _YDEC._WMUX_1.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_2.MXN0 _YDEC._WMUX_2.INYP _YDEC.YSEL[2] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_2.MXN1 YW2 _YDEC._WMUX_2.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_2.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_2.MXP0 _YDEC._WMUX_2.INYP _YDEC.YSEL[2] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_2.MXP1 YW2 _YDEC._WMUX_2.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_2.MXP2 _YDEC._WMUX_2.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_3.MXN0 _YDEC._WMUX_3.INYP _YDEC.YSEL[3] _YDEC.WN1 VPW N11LL_CKT
+  W=0.99U L=0.04U
X_M_ydec._wmux_3.MXN1 YW3 _YDEC._WMUX_3.INYP VSSE VPW N11LL_CKT W=3.4U L=0.04U
X_M_ydec._wmux_3.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.99U L=0.04U
X_M_ydec._wmux_3.MXP0 _YDEC._WMUX_3.INYP _YDEC.YSEL[3] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ydec._wmux_3.MXP1 YW3 _YDEC._WMUX_3.INYP VDDPE VNWP P11LL_CKT W=7.96U
+  L=0.04U
X_M_ydec._wmux_3.MXP2 _YDEC._WMUX_3.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
.ENDS RAMSP1024X16CKM4_BIST
****
.SUBCKT RAMSP1024X16CNTRL ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2
+  CEN CENY CLK CRE1 CRE2 DBL DFTRAM_RET DUMMY_DWL_L_0 DUMMY_DWL_L_1
+  DUMMY_DWL_R DUM_NSAO_L DUM_NSAO_R DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0
+  DUM_PSO1 DUM_SEL_SI DUM_SEL_TD_L DUM_SEL_TD_R DUM_TPEN DWL EMAW0 EMAW1
+  EMA[0] EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6
+  FCA2_0 FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP
+  LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1
+  NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_BOT NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N SAE_DUMMY SAPRECH
+  SEL_D SEL_SI SEL_TD SO0 SO1 TCA2 TE TLA2 TWEN VDDCE VDDC_LEFT VDDC_RIGHT
+  VDDP VDDPE VSS WEN YW0 YW1 YW2 YW3
** RAMSP1024X16CNTRL: 777 flat devices **
XCK ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2
+  DBL LOG0 DFTRAM_RET DUMMY_DWL_L_1 DUMMY_DWL_R LOG0 NWCLK_TOP DUM_PEN
+  DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL DWL EMAW0 EMAW1 EMA[0]
+  EMA[1] EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY IDFTRAMBYP
+  LA_P2[2] LA0 LA1 LA2 LAY0 LAY1 LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NSAO_L NSAO_R NWCLK NWCLK_WT
+  NYR0 NYR1 NYR2 NYR3 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5
+  RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] LOG0 LOG0 RET RET1N SAE_DUMMY
+  SAPRECH LOG0 SEL_D SEL_SI SEL_TD SO0 SO1 LOG0 LOG0 TCA2 LOG0 TE LOG1 LOG0
+  LOG0 LOG0 TLA2 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 VDDCE VDDCE VDDC_LEFT VDDCE
+  VDDC_RIGHT VDDP VDDPE VDDPE VDDCE VDDPE VSS VSS VSS LOG0 YW0 YW1 YW2 YW3
+  RAMSP1024X16CKM4_BIST
.ENDS RAMSP1024X16CNTRL
****
.SUBCKT RAMSP1024X16IOCDM_R BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL2_0 BL2_1 BL2_2 BL2_3
+  BL2_4 BL2_5 BL2_6 BL2_7 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BLPRECH DFTRAMBYP DUMMY_DWL_L DUMMY_DWL_R DUM_SEL_D_L DUM_SEL_D_R
+  DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L DUM_SEL_TD_R DUM_SI DUM_SO DWL D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0 NACT_CC NBL0_0 NBL0_1 NBL0_2 NBL0_3 NBL0_4
+  NBL0_5 NBL0_6 NBL0_7 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4 NBL1_5 NBL1_6
+  NBL1_7 NBL2_0 NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6 NBL2_7 NBL3_0
+  NBL3_1 NBL3_2 NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7 NSAE NWCLK NWCLK_WT NYR0
+  NYR1 NYR2 NYR3 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH
+  SEL_D SEL_SI SEL_TD SI SO TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL
+  TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDCE VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC_0 VNWC_1 VNWC_2
+  VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7 VPW WENL WENR WENY_0 WENY_1 WENY_2
+  WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5
+  WEN_6 WEN_7 YW0 YW1 YW2 YW3
** RAMSP1024X16IOCDM_R: 1288 flat devices **
XR_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D_1 DFTRAMBYP DUMMY_DWL_L_24
+  DUMMY_DWL_R_8 DUM_SEL_D_L_16 DUM_SEL_D_R_0 DUM_SEL_SI_L_18 DUM_SEL_SI_R_2
+  DUM_SEL_TD_L_20 DUM_SEL_TD_R_4 DUM_SI_22 DUM_SO_6 DWL LOG0 NACT_CC NBL0_1
+  NBL1_1 NBL2_1 NBL3_1 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_1 SAPRECH
+  SEL_D SEL_SI SEL_TD SI_26 SO_10 TD_1 TE TWEN_1 TWENL_28 TWENR_12 TWEN_1
+  VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW WEN_1 WENL_30 WENR_14 WENY_1
+  WEN_1 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D_2 DFTRAMBYP DUMMY_DWL_L_40
+  DUMMY_DWL_L_24 DUM_SEL_D_L_32 DUM_SEL_D_L_16 DUM_SEL_SI_L_34
+  DUM_SEL_SI_L_18 DUM_SEL_TD_L_36 DUM_SEL_TD_L_20 DUM_SI_38 DUM_SI_22 DWL
+  LOG0 NACT_CC NBL0_2 NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_2 SAPRECH SEL_D SEL_SI SEL_TD SI_42 SI_26 TD_2 TE TWEN_2 TWENL_44
+  TWENL_28 TWEN_2 VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW WEN_2 WENL_46
+  WENL_30 WENY_2 WEN_2 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_I3 BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D_3 DFTRAMBYP DUMMY_DWL_L_56
+  DUMMY_DWL_L_40 DUM_SEL_D_L_48 DUM_SEL_D_L_32 DUM_SEL_SI_L_50
+  DUM_SEL_SI_L_34 DUM_SEL_TD_L_52 DUM_SEL_TD_L_36 DUM_SI_54 DUM_SI_38 DWL
+  LOG0 NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_3 SAPRECH SEL_D SEL_SI SEL_TD SI_58 SI_42 TD_3 TE TWEN_3 TWENL_60
+  TWENL_44 TWEN_3 VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW WEN_3 WENL_62
+  WENL_46 WENY_3 WEN_3 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_I4 BL0_4 BL1_4 BL2_4 BL3_4 BLPRECH D_4 DFTRAMBYP DUMMY_DWL_L_72
+  DUMMY_DWL_L_56 DUM_SEL_D_L_64 DUM_SEL_D_L_48 DUM_SEL_SI_L_66
+  DUM_SEL_SI_L_50 DUM_SEL_TD_L_68 DUM_SEL_TD_L_52 DUM_SI_70 DUM_SI_54 DWL
+  LOG0 NACT_CC NBL0_4 NBL1_4 NBL2_4 NBL3_4 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_4 SAPRECH SEL_D SEL_SI SEL_TD SI_74 SI_58 TD_4 TE TWEN_4 TWENL_76
+  TWENL_60 TWEN_4 VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW WEN_4 WENL_78
+  WENL_62 WENY_4 WEN_4 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_I5 BL0_5 BL1_5 BL2_5 BL3_5 BLPRECH D_5 DFTRAMBYP DUMMY_DWL_L_88
+  DUMMY_DWL_L_72 DUM_SEL_D_L_80 DUM_SEL_D_L_64 DUM_SEL_SI_L_82
+  DUM_SEL_SI_L_66 DUM_SEL_TD_L_84 DUM_SEL_TD_L_68 DUM_SI_86 DUM_SI_70 DWL
+  LOG0 NACT_CC NBL0_5 NBL1_5 NBL2_5 NBL3_5 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_5 SAPRECH SEL_D SEL_SI SEL_TD SI_90 SI_74 TD_5 TE TWEN_5 TWENL_92
+  TWENL_76 TWEN_5 VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW WEN_5 WENL_94
+  WENL_78 WENY_5 WEN_5 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_I6 BL0_6 BL1_6 BL2_6 BL3_6 BLPRECH D_6 DFTRAMBYP DUMMY_DWL_L_104
+  DUMMY_DWL_L_88 DUM_SEL_D_L_96 DUM_SEL_D_L_80 DUM_SEL_SI_L_98
+  DUM_SEL_SI_L_82 DUM_SEL_TD_L_100 DUM_SEL_TD_L_84 DUM_SI_102 DUM_SI_86 DWL
+  LOG0 NACT_CC NBL0_6 NBL1_6 NBL2_6 NBL3_6 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2
+  NYR3 SAO_6 SAPRECH SEL_D SEL_SI SEL_TD SI_106 SI_90 TD_6 TE TWEN_6
+  TWENL_108 TWENL_92 TWEN_6 VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW WEN_6
+  WENL_110 WENL_94 WENY_6 WEN_6 YW0 YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D_0 DFTRAMBYP DUMMY_DWL_R_8
+  DUMMY_DWL_R DUM_SEL_D_R_0 DUM_SEL_D_R DUM_SEL_SI_R_2 DUM_SEL_SI_R
+  DUM_SEL_TD_R_4 DUM_SEL_TD_R DUM_SO_6 DUM_SO DWL LOG0 NACT_CC NBL0_0 NBL1_0
+  NBL2_0 NBL3_0 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_0 SAPRECH SEL_D
+  SEL_SI SEL_TD SO_10 SO TD_0 TE TWEN_0 TWENR_12 TWENR TWEN_0 VDDC_0 VDDCE
+  VDDPE VNWC_0 VDDPE VPW VPW VPW WEN_0 WENR_14 WENR WENY_0 WEN_0 YW0 YW1 YW2
+  YW3 RAMSP1024X16COLM4_BIST_WM
XR_IO_R BL0_7 BL1_7 BL2_7 BL3_7 BLPRECH D_7 DFTRAMBYP DUMMY_DWL_L
+  DUMMY_DWL_L_104 DUM_SEL_D_L DUM_SEL_D_L_96 DUM_SEL_SI_L DUM_SEL_SI_L_98
+  DUM_SEL_TD_L DUM_SEL_TD_L_100 DUM_SI DUM_SI_102 DWL LOG0 NACT_CC NBL0_7
+  NBL1_7 NBL2_7 NBL3_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_7 SAPRECH
+  SEL_D SEL_SI SEL_TD SI SI_106 TD_7 TE TWEN_7 TWENL TWENL_108 TWEN_7 VDDC_7
+  VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW WEN_7 WENL WENL_110 WENY_7 WEN_7 YW0
+  YW1 YW2 YW3 RAMSP1024X16COLM4_BIST_WM
.ENDS RAMSP1024X16IOCDM_R
****
.SUBCKT RAMSP1024X16IO_RDM_R DUM_SEL_SI_L DUM_SEL_SI_R DUM_SEL_TD_L
+  DUM_SEL_TD_R DUM_SI DUM_SO DWL_L DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0
+  Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7
+  TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4
+  TWEN_5 TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1
+  VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSS WENY_0 WENY_1 WENY_2 WENY_3 WENY_4
+  WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
** RAMSP1024X16IO_RDM_R: 16 flat devices **
XR_RDM_1 D_1 DUM_SEL_SI_L_8 DUM_SEL_SI_L_0 DUM_SEL_TD_L_10 DUM_SEL_TD_L_2
+  DUM_SO_4 DUM_SO_12 DWL_L_14 DWL_L_6 Q_1 SAO_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1
+  VNWP_1 VPW_1 VSS VSS WEN_1 WENY_1 RAMSP1024X16RDM4
XR_RDM_2 D_2 DUM_SEL_SI_L_24 DUM_SEL_SI_L_8 DUM_SEL_TD_L_26 DUM_SEL_TD_L_10
+  DUM_SO_12 DUM_SO_28 DWL_L_30 DWL_L_14 Q_2 SAO_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2
+  VNWP_2 VPW_2 VSS VSS WEN_2 WENY_2 RAMSP1024X16RDM4
XR_RDM_3 D_3 DUM_SEL_SI_L_32 DUM_SEL_SI_L_24 DUM_SEL_TD_L_34 DUM_SEL_TD_L_26
+  DUM_SO_28 DUM_SO_36 DWL_L_38 DWL_L_30 Q_3 SAO_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3
+  VNWP_3 VPW_3 VSS VSS WEN_3 WENY_3 RAMSP1024X16RDM4
XR_RDM_4 D_4 DUM_SEL_SI_L_40 DUM_SEL_SI_L_32 DUM_SEL_TD_L_42 DUM_SEL_TD_L_34
+  DUM_SO_36 DUM_SO_44 DWL_L_46 DWL_L_38 Q_4 SAO_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4
+  VNWP_4 VPW_4 VSS VSS WEN_4 WENY_4 RAMSP1024X16RDM4
XR_RDM_5 D_5 DUM_SEL_SI_L_48 DUM_SEL_SI_L_40 DUM_SEL_TD_L_50 DUM_SEL_TD_L_42
+  DUM_SO_44 DUM_SO_52 DWL_L_54 DWL_L_46 Q_5 SAO_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5
+  VNWP_5 VPW_5 VSS VSS WEN_5 WENY_5 RAMSP1024X16RDM4
XR_RDM_6 D_6 DUM_SEL_SI_R_16 DUM_SEL_SI_L_48 DUM_SEL_TD_R_18 DUM_SEL_TD_L_50
+  DUM_SO_52 DUM_SI_20 DWL_R_22 DWL_L_54 Q_6 SAO_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6
+  VNWP_6 VPW_6 VSS VSS WEN_6 WENY_6 RAMSP1024X16RDM4
XR_RDM_L D_0 DUM_SEL_SI_L_0 DUM_SEL_SI_R DUM_SEL_TD_L_2 DUM_SEL_TD_R DUM_SI
+  DUM_SO_4 DWL_L_6 DWL_R Q_0 SAO_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0
+  VSS VSS WEN_0 WENY_0 RAMSP1024X16RDM4
XR_RDM_R D_7 DUM_SEL_SI_L DUM_SEL_SI_R_16 DUM_SEL_TD_L DUM_SEL_TD_R_18
+  DUM_SI_20 DUM_SO DWL_L DWL_R_22 Q_7 SAO_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7
+  VNWP_7 VPW_7 VSS VSS WEN_7 WENY_7 RAMSP1024X16RDM4
.ENDS RAMSP1024X16IO_RDM_R
****
.SUBCKT RAMSP1024X16IOTOPCAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW
** RAMSP1024X16IOTOPCAP_R: 256 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW RAMSP1024X16CCHD4_TOPBOT
.ENDS RAMSP1024X16IOTOPCAP_R
****
.SUBCKT RAMSP1024X16IO_ROW_R BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  DFTRAMBYP DUMMY_DWL_R DUM_SEL_D_R DUM_SEL_SI_R_0 DUM_SEL_SI_R_1
+  DUM_SEL_TD_R_0 DUM_SEL_TD_R_1 DUM_SI DUM_SO DWL DWL_R D_0 D_1 D_2 D_3 D_4
+  D_5 D_6 D_7 LOG0_0 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3
+  Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SO TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4
+  TWEN_5 TWEN_6 TWEN_7 VDDC VDDPE VPW WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4
+  WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0
+  YW1 YW2 YW3
** RAMSP1024X16IO_ROW_R: 1565 flat devices **
XIO_CDM_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BLPRECH DFTRAMBYP
+  DUMMY_DWL_L DUMMY_DWL_R DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_SI_L DUM_SEL_SI_R_1
+  DUM_SEL_TD_L DUM_SEL_TD_R_1 DUM_SI_8 DUM_SO DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6
+  D_7 LOG0_1 NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5
+  NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5
+  NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAO_0 SAO_1 SAO_2
+  SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 SO TD_0
+  TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2
+  TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDPE VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VPW WENL WENR WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3
+  WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3 RAMSP1024X16IOCDM_R
XIO_EDGE_R BLPRECH DFTRAMBYP DUMMY_DWL_L DUM_SEL_D_L DUM_SEL_SI_0 DUM_SEL_SI_L
+  DUM_SEL_TD_0 DUM_SEL_TD_L DUM_SI_0 DUM_SI_8 DWL LOG0_1 NACT_CC NSAE NWCLK
+  NWCLK_WT NYR0 NYR1 NYR2 NYR3 SAPRECH SEL_D SEL_SI SEL_TD LOG0_0 TE TWENL
+  VDDC VDDC VDDPE VDDC VPW VPW VPW WENL YW0 YW1 YW2 YW3 RAMSP1024X16IOEDGE
XIO_RDM_ROW_R DUM_SEL_SI_0 DUM_SEL_SI_R_0 DUM_SEL_TD_0 DUM_SEL_TD_R_0 DUM_SI
+  DUM_SI_0 DWL DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5
+  Q_6 Q_7 SAO_0 SAO_1 SAO_2 SAO_3 SAO_4 SAO_5 SAO_6 SAO_7 TD_0 TD_1 TD_2 TD_3
+  TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7
+  WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMSP1024X16IO_RDM_R
XIO_TOPCAP_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW RAMSP1024X16IOTOPCAP_R
.ENDS RAMSP1024X16IO_ROW_R
****
.SUBCKT RAMSP1024X16IO_SLICE ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 CA0 CA1 CA2
+  CAY0 CAY1 CAY2 CEN CENY CLK CRE1 CRE2 DBL DFTRAM_RET DUMMY_DWL_R DUM_PEN
+  DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_TPEN DWL_WDX D_0 D_1 D_2 D_3 D_4
+  D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMAW0 EMAW1 EMA[0] EMA[1]
+  EMA[2] FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1
+  FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY LA0 LA1 LA2 LAY0 LAY1
+  LAY2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_1 LOG0_2 LOG0_DWL LOG1 NACTC
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5
+  NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5
+  NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NGWE NRETNVT NWCLK_BOT Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RA0 RA1 RA2 RA3 RA4 RA5 RAY0 RAY1
+  RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N
+  SAE_DUMMY SEL_D SEL_SI SEL_TD SO0 SO1 TCA2 TD_0 TD_1 TD_2 TD_3 TD_4 TD_5
+  TD_6 TD_7 TD_8 TD_9 TD_10 TD_11 TD_12 TD_13 TD_14 TD_15 TLA2 TWEN_0 TWEN_1
+  TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 TWEN_8 TWEN_9 TWEN_10 TWEN_11
+  TWEN_12 TWEN_13 TWEN_14 TWEN_15 VDDC VDDP VDDPE VPW WENY_0 WENY_1 WENY_2
+  WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WENY_8 WENY_9 WENY_10 WENY_11 WENY_12
+  WENY_13 WENY_14 WENY_15 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMSP1024X16IO_SLICE: 3907 flat devices **
XCK_BLK ACTP BLPRECH BLPRECH_R CA0 CA1 CA2 CAY0 CAY1 CAY2 CEN CENY CLK CRE1
+  CRE2 DBL DFTRAM_RET DWL_R DUMMY_DWL_R_16 DUMMY_DWL_R DUM_SI DUM_NSAO_R
+  DUM_PEN DUM_PENSI DUM_PENSO DUM_PSO0 DUM_PSO1 DUM_SEL_SI_R_0 DUM_SEL_TD_R_0
+  DUM_SEL_TD_R DUM_TPEN DWL_WDX EMAW0 EMAW1 EMA[0] EMA[1] EMA[2] FCA1_0
+  FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0 FCA2_1 FCA2_2 FCA2_3
+  FCA2_4 FCA2_5 FCA2_6 GTP GWEN GWENY DFTRAMBYP LA0 LA1 LA2 LAY0 LAY1 LAY2
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0 LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT
+  NSAE DUM_SO NSAO_R NWCLK NWCLK_BOT NWCLK_WT NYR0 NYR1 NYR2 NYR3 RA0 RA1 RA2
+  RA3 RA4 RA5 RAY0 RAY1 RAY2 RAY3 RAY4 RAY5 RA_P2[0] RA_P2[1] RA_P2[2]
+  RA_P2[3] RA_P2[4] RET RET1N SAE_DUMMY SAPRECH SEL_D SEL_SI SEL_TD SO0 SO1
+  TCA2 TE TLA2 TWENR VDDC VDDC VDDC VDDP VDDPE VPW WENR YW0 YW1 YW2 YW3
+  RAMSP1024X16CNTRL
XIO_LEFT BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 DFTRAMBYP
+  DUMMY_DWL_R_16 SEL_D DUM_SEL_SI_R_0 SEL_SI DUM_SEL_TD_R_0 SEL_TD DUM_SI
+  DUM_SO LOG0_0 DWL_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 LOG0_1 LOG0_0 NACT_CC
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  SAPRECH SEL_D SEL_SI SEL_TD DUM_SO TD_0 TD_1 TD_2 TD_3 TD_4 TD_5 TD_6 TD_7
+  TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5 TWEN_6 TWEN_7 VDDC VDDPE
+  VPW WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0
+  WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 YW0 YW1 YW2 YW3
+  RAMSP1024X16IO_ROW_L
XIO_RIGHT BLPRECH_R BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13
+  BL[2]_14 BL[2]_15 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 DFTRAMBYP DUMMY_DWL_R SEL_D DUM_SEL_SI_R_0 SEL_SI
+  DUM_SEL_TD_R SEL_TD DUM_NSAO_R NSAO_R DWL_WDX DUMMY_DWL_R D_8 D_9 D_10 D_11
+  D_12 D_13 D_14 D_15 LOG0_2 LOG0_0 NACT_CC NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 NSAE NWCLK NWCLK_WT NYR0 NYR1 NYR2 NYR3 Q_8 Q_9 Q_10 Q_11 Q_12
+  Q_13 Q_14 Q_15 SAPRECH SEL_D SEL_SI SEL_TD NSAO_R TD_8 TD_9 TD_10 TD_11
+  TD_12 TD_13 TD_14 TD_15 TE TWENR TWEN_8 TWEN_9 TWEN_10 TWEN_11 TWEN_12
+  TWEN_13 TWEN_14 TWEN_15 VDDC VDDPE VPW WENR WENY_8 WENY_9 WENY_10 WENY_11
+  WENY_12 WENY_13 WENY_14 WENY_15 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13
+  WEN_14 WEN_15 YW0 YW1 YW2 YW3 RAMSP1024X16IO_ROW_R
.ENDS RAMSP1024X16IO_SLICE
****
.SUBCKT RAMSP1024X16CCHD4_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP1024X16CCHD4_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4_EDG
****
.SUBCKT RAMSP1024X16CCHD4WD_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** RAMSP1024X16CCHD4WD_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4WD_EDG
****
.SUBCKT RAMSP1024X16CCHD4 BL[0] BL[1] BL[2] BL[3] CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0] NBL[1] NBL[2] NBL[3]
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC VDDCE VDDPE VNWC VPW VSSE WL[0] WL[1]
** RAMSP1024X16CCHD4: 48 flat devices **
X_MI17._cell.MXN0 NCORED30 CORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXN1 NBL[3] WL[0] NCORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN2 BL[3] WL[0] CORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN3 CORED30 NCORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXP0 NCORED30 CORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI17._cell.MXP1 CORED30 NCORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXN0 NCORED20 CORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXN1 NBL[2] WL[0] NCORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN2 BL[2] WL[0] CORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN3 CORED20 NCORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXP0 NCORED20 CORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXP1 CORED20 NCORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXN0 NCORED10 CORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXN1 NBL[1] WL[0] NCORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN2 BL[1] WL[0] CORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN3 CORED10 NCORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXP0 NCORED10 CORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXP1 CORED10 NCORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXN0 NCORED00 CORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXN1 NBL[0] WL[0] NCORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN2 BL[0] WL[0] CORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN3 CORED00 NCORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXP0 NCORED00 CORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXP1 CORED00 NCORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_M_cell01._cell.MXN0 NCORED01 CORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXN1 NBL[0] WL[1] NCORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN2 BL[0] WL[1] CORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN3 CORED01 NCORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXP0 NCORED01 CORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell01._cell.MXP1 CORED01 NCORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXN0 NCORED11 CORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXN1 NBL[1] WL[1] NCORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN2 BL[1] WL[1] CORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN3 CORED11 NCORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXP0 NCORED11 CORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXP1 CORED11 NCORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXN0 NCORED21 CORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXN1 NBL[2] WL[1] NCORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN2 BL[2] WL[1] CORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN3 CORED21 NCORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXP0 NCORED21 CORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXP1 CORED21 NCORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXN0 NCORED31 CORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXN1 NBL[3] WL[1] NCORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN2 BL[3] WL[1] CORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN3 CORED31 NCORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXP0 NCORED31 CORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXP1 CORED31 NCORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
.ENDS RAMSP1024X16CCHD4
****
.SUBCKT RAMSP1024X16MEM_L_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDCE_0
+  VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1
+  VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_ROW: 388 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
.ENDS RAMSP1024X16MEM_L_ROW
****
.SUBCKT RAMSP1024X16MEM_L_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_MIDT_ROW: 388 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
.ENDS RAMSP1024X16MEM_L_MIDT_ROW
****
.SUBCKT RAMSP1024X16CCHD4_EDG_STRAP VNWC VNWP VPW VSSE
** RAMSP1024X16CCHD4_EDG_STRAP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4_EDG_STRAP
****
.SUBCKT RAMSP1024X16CCHD4WD_EDG_STRP VNWC VNWP VPW VSSE
** RAMSP1024X16CCHD4WD_EDG_STRP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4WD_EDG_STRP
****
.SUBCKT RAMSP1024X16CCHD4_STRAP BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** RAMSP1024X16CCHD4_STRAP: 24 flat devices **
X_MXN36 VSSE NET96 NET107 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN37 VSSE NET76 NET139 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN38 NBL[2] VPW NET135 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN39 NBL[3] VPW NET159 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN40 NET130 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN41 NBL[2] VPW NET127 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN42 VSSE NET100 NET151 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN43 VSSE NET92 NET123 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN44 VSSE NET88 NET163 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN45 VSSE NET72 NET115 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN46 NBL[0] VPW NET155 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN47 NET118 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN48 NBL[1] VPW NET143 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN49 NBL[0] VPW NET111 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN50 VSSE NET84 NET103 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN51 VSSE NET80 NET147 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET95 NET96 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 NET75 NET76 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 NET99 NET100 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 VDDC NET92 NET89 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 VDDC NET88 NET85 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 NET71 NET72 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP18 NET83 NET84 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP19 NET79 NET80 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMSP1024X16CCHD4_STRAP
****
.SUBCKT RAMSP1024X16MEM_L_STRAPROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC VNWP_0 VNWP_1 VPW
** RAMSP1024X16MEM_L_STRAPROW: 196 flat devices **
XMEM_STRAP0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC_0 VNWC VDDPE_0 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC_1 VNWC VDDPE_1 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC_2 VNWC VDDPE_2 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC_3 VNWC VDDPE_3 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC_4 VNWC VDDPE_4 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC_5 VNWC VDDPE_5 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC_6 VNWC VDDPE_6 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC_7 VNWC VDDPE_7 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAPEDGEL VNWC VNWP_0 VPW VPW RAMSP1024X16CCHD4_EDG_STRAP
XMEM_STRAPEDGER VNWC VNWP_1 VPW VPW RAMSP1024X16CCHD4WD_EDG_STRP
.ENDS RAMSP1024X16MEM_L_STRAPROW
****
.SUBCKT RAMSP1024X16MEM_L_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_MID_ROW: 388 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
.ENDS RAMSP1024X16MEM_L_MID_ROW
****
.SUBCKT RAMSP1024X16MEM_L_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_BOT_ROW: 388 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_1 VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_4 NBL[1]_4
+  NBL[2]_4 NBL[3]_4 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_4 VDDCE_4 VDDPE_4
+  VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_BOT_R BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
.ENDS RAMSP1024X16MEM_L_BOT_ROW
****
.SUBCKT RAMSP1024X16CCHD4WD_CORNER VDDC VNWC VNWP VPW VSSE
** RAMSP1024X16CCHD4WD_CORNER: 3 flat devices **
X_MXN0 VSSE NET19 NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET15 NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS RAMSP1024X16CCHD4WD_CORNER
****
.SUBCKT RAMSP1024X16MEM_SLICE_CAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0
+  VNWP_1 VSSE
** RAMSP1024X16MEM_SLICE_CAP_L: 262 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VSSE VSSE RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VDDC VDDC VNWP_0 VSSE VSSE RAMSP1024X16CCHD4_CORNER
XTOP_EDGE_ROWEDGER VDDC VDDC VNWP_1 VSSE VSSE RAMSP1024X16CCHD4WD_CORNER
.ENDS RAMSP1024X16MEM_SLICE_CAP_L
****
.SUBCKT RAMSP1024X16MEM_L_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_TOP_ROW: 388 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_L_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_TOP_R BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_7
+  NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_7 VDDCE_7 VDDPE_7
+  VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
.ENDS RAMSP1024X16MEM_L_TOP_ROW
****
.SUBCKT RAMSP1024X16MEM_L_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL[0] WL[1]
** RAMSP1024X16MEM_L_MIDB_ROW: 388 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_1 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_2 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_3 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_L_COL_EDGER VNWC_9 VNWP_1 VSSE VSSE WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
.ENDS RAMSP1024X16MEM_L_MIDB_ROW
****
.SUBCKT RAMSP1024X16MEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0 VNWP_1 VSSE
+  WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8
+  WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16
+  WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24
+  WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[0]_32
+  WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39 WL[0]_40
+  WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47 WL[0]_48
+  WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55 WL[0]_56
+  WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63 WL[0]_64
+  WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71 WL[0]_72
+  WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79 WL[0]_80
+  WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87 WL[0]_88
+  WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95 WL[0]_96
+  WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103
+  WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110
+  WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[0]_116 WL[0]_117
+  WL[0]_118 WL[0]_119 WL[0]_120 WL[0]_121 WL[0]_122 WL[0]_123 WL[0]_124
+  WL[0]_125 WL[0]_126 WL[0]_127 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4
+  WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13
+  WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21
+  WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29
+  WL[1]_30 WL[1]_31 WL[1]_32 WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37
+  WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45
+  WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53
+  WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61
+  WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69
+  WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77
+  WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85
+  WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93
+  WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101
+  WL[1]_102 WL[1]_103 WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108
+  WL[1]_109 WL[1]_110 WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115
+  WL[1]_116 WL[1]_117 WL[1]_118 WL[1]_119 WL[1]_120 WL[1]_121 WL[1]_122
+  WL[1]_123 WL[1]_124 WL[1]_125 WL[1]_126 WL[1]_127
** RAMSP1024X16MEMCORE_L: 50122 flat devices **
XMEM_L_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_1 WL[1]_1 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_10 WL[1]_10 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_100 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_100 WL[1]_100 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_101 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_101 WL[1]_101 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_102 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_102 WL[1]_102 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_103 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_103 WL[1]_103 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_104 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_104 WL[1]_104 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_105 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_105 WL[1]_105 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_106 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_106 WL[1]_106 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_107 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_107 WL[1]_107 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_108 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_108 WL[1]_108 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_109 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_109 WL[1]_109 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_11 WL[1]_11 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_110 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_110 WL[1]_110 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_111 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_111 WL[1]_111 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_112 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_112 WL[1]_112 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_113 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_113 WL[1]_113 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_114 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_114 WL[1]_114 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_115 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_115 WL[1]_115 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_116 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_116 WL[1]_116 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_117 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_117 WL[1]_117 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_118 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_118 WL[1]_118 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_119 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_119 WL[1]_119 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_12 WL[1]_12 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_120 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_120 WL[1]_120 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_121 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_121 WL[1]_121 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_122 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_122 WL[1]_122 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_123 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_123 WL[1]_123 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_124 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_124 WL[1]_124 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_125 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_125 WL[1]_125 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_126 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_126 WL[1]_126 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_13 WL[1]_13 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_14 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_14 WL[1]_14 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_15 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_15 WL[1]_15 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_16 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_16 WL[1]_16 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_17 WL[1]_17 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_18 WL[1]_18 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_19 WL[1]_19 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_2 WL[1]_2 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_20 WL[1]_20 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_21 WL[1]_21 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_22 WL[1]_22 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_23 WL[1]_23 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_24 WL[1]_24 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_25 WL[1]_25 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_26 WL[1]_26 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_27 WL[1]_27 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_28 WL[1]_28 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_29 WL[1]_29 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_3 WL[1]_3 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_30 WL[1]_30 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_31 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_31 WL[1]_31 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_32 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_32 WL[1]_32 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_33 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_33 WL[1]_33 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_34 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_34 WL[1]_34 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_35 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_35 WL[1]_35 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_36 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_36 WL[1]_36 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_37 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_37 WL[1]_37 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_38 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_38 WL[1]_38 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_39 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_39 WL[1]_39 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_4 WL[1]_4 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_40 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_40 WL[1]_40 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_41 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_41 WL[1]_41 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_42 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_42 WL[1]_42 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_43 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_43 WL[1]_43 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_44 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_44 WL[1]_44 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_45 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_45 WL[1]_45 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_46 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_46 WL[1]_46 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_47 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_47 WL[1]_47 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_48 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_48 WL[1]_48 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_49 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_49 WL[1]_49 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_5 WL[1]_5 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_50 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_50 WL[1]_50 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_51 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_51 WL[1]_51 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_52 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_52 WL[1]_52 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_53 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_53 WL[1]_53 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_54 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_54 WL[1]_54 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_55 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_55 WL[1]_55 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_56 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_56 WL[1]_56 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_57 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_57 WL[1]_57 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_58 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_58 WL[1]_58 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_59 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_59 WL[1]_59 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_6 WL[1]_6 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_60 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_60 WL[1]_60 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_61 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_61 WL[1]_61 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_65 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_65 WL[1]_65 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_66 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_66 WL[1]_66 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_67 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_67 WL[1]_67 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_68 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_68 WL[1]_68 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_69 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_69 WL[1]_69 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_7 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_7 WL[1]_7 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_70 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_70 WL[1]_70 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_71 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_71 WL[1]_71 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_72 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_72 WL[1]_72 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_73 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_73 WL[1]_73 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_74 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_74 WL[1]_74 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_75 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_75 WL[1]_75 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_76 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_76 WL[1]_76 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_77 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_77 WL[1]_77 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_78 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_78 WL[1]_78 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_79 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_79 WL[1]_79 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_8 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_8 WL[1]_8 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_80 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_80 WL[1]_80 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_81 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_81 WL[1]_81 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_82 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_82 WL[1]_82 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_83 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_83 WL[1]_83 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_84 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_84 WL[1]_84 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_85 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_85 WL[1]_85 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_86 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_86 WL[1]_86 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_87 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_87 WL[1]_87 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_88 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_88 WL[1]_88 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_89 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_89 WL[1]_89 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_9 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_9 WL[1]_9 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_90 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_90 WL[1]_90 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_91 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_91 WL[1]_91 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_92 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_92 WL[1]_92 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_93 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_93 WL[1]_93 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_94 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_94 WL[1]_94 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_95 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_95 WL[1]_95 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_96 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_96 WL[1]_96 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_97 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_97 WL[1]_97 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_98 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_98 WL[1]_98 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_99 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_99 WL[1]_99 RAMSP1024X16MEM_L_ROW
XMEM_L_ROW_BOT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_0 WL[1]_0 RAMSP1024X16MEM_L_BOT_ROW
XMEM_L_ROW_CAP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0 VNWP_1 VSSE
+  RAMSP1024X16MEM_SLICE_CAP_L
XMEM_L_ROW_MID BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_63 WL[1]_63 RAMSP1024X16MEM_L_MID_ROW
XMEM_L_ROW_MIDB BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE WL[0]_62 WL[1]_62 RAMSP1024X16MEM_L_MIDB_ROW
XMEM_L_ROW_MIDT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE WL[0]_64 WL[1]_64 RAMSP1024X16MEM_L_MIDT_ROW
XMEM_L_ROW_TOP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_127 WL[1]_127 RAMSP1024X16MEM_L_TOP_ROW
XMEM_L_STRAP0 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDC VNWP_0 VNWP_1 VSSE RAMSP1024X16MEM_L_STRAPROW
.ENDS RAMSP1024X16MEMCORE_L
****
.SUBCKT RAMSP1024X16MEM_R_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDCE_0
+  VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1
+  VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4
+  VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_ROW: 388 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
.ENDS RAMSP1024X16MEM_R_ROW
****
.SUBCKT RAMSP1024X16MEM_R_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_MID_ROW: 388 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
.ENDS RAMSP1024X16MEM_R_MID_ROW
****
.SUBCKT RAMSP1024X16MEM_R_STRAPROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC VNWP_0 VNWP_1 VPW
** RAMSP1024X16MEM_R_STRAPROW: 196 flat devices **
XMEM_STRAP0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC_0 VNWC VDDPE_0 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC_1 VNWC VDDPE_1 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC_2 VNWC VDDPE_2 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC_3 VNWC VDDPE_3 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC_4 VNWC VDDPE_4 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC_5 VNWC VDDPE_5 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC_6 VNWC VDDPE_6 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAP7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC_7 VNWC VDDPE_7 VNWC VPW VPW RAMSP1024X16CCHD4_STRAP
XMEM_STRAPEDGEL VNWC VNWP_0 VPW VPW RAMSP1024X16CCHD4WD_EDG_STRP
XMEM_STRAPEDGER VNWC VNWP_1 VPW VPW RAMSP1024X16CCHD4_EDG_STRAP
.ENDS RAMSP1024X16MEM_R_STRAPROW
****
.SUBCKT RAMSP1024X16MEM_R_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_BOT_ROW: 388 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_BOT_R BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_7 VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
.ENDS RAMSP1024X16MEM_R_BOT_ROW
****
.SUBCKT RAMSP1024X16MEM_R_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_MIDB_ROW: 388 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
.ENDS RAMSP1024X16MEM_R_MIDB_ROW
****
.SUBCKT RAMSP1024X16MEM_R_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_MIDT_ROW: 388 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10 CORED11
+  CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_16 CORED01_18 CORED10_20
+  CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_3 NBL[1]_3
+  NBL[2]_3 NBL[3]_3 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
.ENDS RAMSP1024X16MEM_R_MIDT_ROW
****
.SUBCKT RAMSP1024X16MEM_SLICE_CAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC VNWP_0
+  VNWP_1 VPW
** RAMSP1024X16MEM_SLICE_CAP_R: 262 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VNWC VNWC VDDPE_0 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VNWC VNWC VDDPE_1 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VNWC VNWC VDDPE_2 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VNWC VNWC VDDPE_3 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VNWC VNWC VDDPE_4 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VNWC VNWC VDDPE_5 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VNWC VNWC VDDPE_6 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROW7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VNWC VNWC VDDPE_7 VNWC VPW VPW RAMSP1024X16CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VNWC VNWC VNWP_0 VPW VPW RAMSP1024X16CCHD4WD_CORNER
XTOP_EDGE_ROWEDGER VNWC VNWC VNWP_1 VPW VPW RAMSP1024X16CCHD4_CORNER
.ENDS RAMSP1024X16MEM_SLICE_CAP_R
****
.SUBCKT RAMSP1024X16MEM_R_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5
+  BL[1]_6 BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6
+  BL[2]_7 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7
+  NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0
+  VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 WL[0] WL[1]
** RAMSP1024X16MEM_R_TOP_ROW: 388 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_48 CORED01_50 CORED10_52
+  CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_1 NBL[1]_1
+  NBL[2]_1 NBL[3]_1 NCORED00_64 NCORED01_66 NCORED10_68 NCORED11_70
+  NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_1 VDDCE_1 VDDPE_1
+  VNWC_2 VPW_2 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_80 CORED01_82 CORED10_84
+  CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_2 NBL[1]_2
+  NBL[2]_2 NBL[3]_2 NCORED00_96 NCORED01_98 NCORED10_100 NCORED11_102
+  NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_2 VDDCE_2 VDDPE_2
+  VNWC_3 VPW_3 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_128 NCORED01_130 NCORED10_132
+  NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140 NCORED31_142 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_160 NCORED01_162 NCORED10_164
+  NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172 NCORED31_174 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_192 NCORED01_194 NCORED10_196
+  NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204 NCORED31_206 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_224 NCORED01_226 NCORED10_228
+  NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236 NCORED31_238 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_9 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4_EDG
XMEM_R_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
XMEM_R_COL_TOP_R BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_7
+  NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_32 NCORED01_34 NCORED10_36 NCORED11_38
+  NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_7 VDDCE_7 VDDPE_7
+  VNWC_8 VPW_8 VPW_0 WL[0] WL[1] RAMSP1024X16CCHD4
.ENDS RAMSP1024X16MEM_R_TOP_ROW
****
.SUBCKT RAMSP1024X16MEMCORE_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0
+  NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0
+  NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWP_0 VNWP_1 VPW
+  WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8
+  WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16
+  WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24
+  WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[0]_32
+  WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39 WL[0]_40
+  WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47 WL[0]_48
+  WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55 WL[0]_56
+  WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63 WL[0]_64
+  WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71 WL[0]_72
+  WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79 WL[0]_80
+  WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87 WL[0]_88
+  WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95 WL[0]_96
+  WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103
+  WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110
+  WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[0]_116 WL[0]_117
+  WL[0]_118 WL[0]_119 WL[0]_120 WL[0]_121 WL[0]_122 WL[0]_123 WL[0]_124
+  WL[0]_125 WL[0]_126 WL[0]_127 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4
+  WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13
+  WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21
+  WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29
+  WL[1]_30 WL[1]_31 WL[1]_32 WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37
+  WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45
+  WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53
+  WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61
+  WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69
+  WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77
+  WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85
+  WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93
+  WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101
+  WL[1]_102 WL[1]_103 WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108
+  WL[1]_109 WL[1]_110 WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115
+  WL[1]_116 WL[1]_117 WL[1]_118 WL[1]_119 WL[1]_120 WL[1]_121 WL[1]_122
+  WL[1]_123 WL[1]_124 WL[1]_125 WL[1]_126 WL[1]_127
** RAMSP1024X16MEMCORE_R: 50122 flat devices **
XMEM_R_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_1
+  WL[1]_1 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_10
+  WL[1]_10 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_100 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_100
+  WL[1]_100 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_101 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_101
+  WL[1]_101 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_102 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_102
+  WL[1]_102 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_103 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_103
+  WL[1]_103 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_104 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_104
+  WL[1]_104 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_105 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_105
+  WL[1]_105 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_106 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_106
+  WL[1]_106 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_107 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_107
+  WL[1]_107 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_108 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_108
+  WL[1]_108 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_109 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_109
+  WL[1]_109 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_11
+  WL[1]_11 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_110 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_110
+  WL[1]_110 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_111 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_111
+  WL[1]_111 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_112 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_112
+  WL[1]_112 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_113 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_113
+  WL[1]_113 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_114 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_114
+  WL[1]_114 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_115 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_115
+  WL[1]_115 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_116 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_116
+  WL[1]_116 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_117 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_117
+  WL[1]_117 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_118 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_118
+  WL[1]_118 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_119 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_119
+  WL[1]_119 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_12
+  WL[1]_12 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_120 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_120
+  WL[1]_120 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_121 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_121
+  WL[1]_121 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_122 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_122
+  WL[1]_122 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_123 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_123
+  WL[1]_123 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_124 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_124
+  WL[1]_124 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_125 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_125
+  WL[1]_125 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_126 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_126
+  WL[1]_126 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_13
+  WL[1]_13 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_14 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_14
+  WL[1]_14 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_15 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_15
+  WL[1]_15 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_16 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_16
+  WL[1]_16 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_17
+  WL[1]_17 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_18
+  WL[1]_18 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_19
+  WL[1]_19 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_2
+  WL[1]_2 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_20
+  WL[1]_20 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_21
+  WL[1]_21 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_22
+  WL[1]_22 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_23
+  WL[1]_23 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_24
+  WL[1]_24 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_25
+  WL[1]_25 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_26
+  WL[1]_26 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_27
+  WL[1]_27 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_28
+  WL[1]_28 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_29
+  WL[1]_29 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_3
+  WL[1]_3 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_30
+  WL[1]_30 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_31 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_31
+  WL[1]_31 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_32 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_32
+  WL[1]_32 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_33 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_33
+  WL[1]_33 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_34 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_34
+  WL[1]_34 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_35 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_35
+  WL[1]_35 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_36 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_36
+  WL[1]_36 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_37 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_37
+  WL[1]_37 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_38 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_38
+  WL[1]_38 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_39 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_39
+  WL[1]_39 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_4
+  WL[1]_4 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_40 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_40
+  WL[1]_40 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_41 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_41
+  WL[1]_41 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_42 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_42
+  WL[1]_42 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_43 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_43
+  WL[1]_43 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_44 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_44
+  WL[1]_44 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_45 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_45
+  WL[1]_45 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_46 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_46
+  WL[1]_46 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_47 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_47
+  WL[1]_47 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_48 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_48
+  WL[1]_48 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_49 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_49
+  WL[1]_49 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_5
+  WL[1]_5 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_50 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_50
+  WL[1]_50 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_51 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_51
+  WL[1]_51 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_52 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_52
+  WL[1]_52 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_53 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_53
+  WL[1]_53 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_54 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_54
+  WL[1]_54 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_55 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_55
+  WL[1]_55 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_56 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_56
+  WL[1]_56 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_57 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_57
+  WL[1]_57 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_58 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_58
+  WL[1]_58 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_59 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_59
+  WL[1]_59 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_6
+  WL[1]_6 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_60 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_60
+  WL[1]_60 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_61 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
+  BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[1]_0 NBL[1]_1 NBL[1]_2
+  NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[2]_0 NBL[2]_1 NBL[2]_2
+  NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[3]_0 NBL[3]_1 NBL[3]_2
+  NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_61
+  WL[1]_61 RAMSP1024X16MEM_R_ROW
XMEM_R_ROW_65 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[2]_0
+  BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[3]_0 BL[3]_1
