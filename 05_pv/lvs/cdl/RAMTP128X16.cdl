+  DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15]
+  EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] AA[1] AA[2] AB[1] AB[2]
+  QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11]
+  QA[12] QA[13] QA[14] QA[15] AA[3] AA[4] AA[5] AA[6] AB[3] AB[4] AB[5] AB[6]
+  RET1N VDDCE VDDPE VSSE WENB[0] WENB[1] WENB[2] WENB[3] WENB[4] WENB[5]
+  WENB[6] WENB[7] WENB[8] WENB[9] WENB[10] WENB[11] WENB[12] WENB[13]
+  WENB[14] WENB[15] RAMTP128X16TTOP
.ENDS RAMTP128X16
