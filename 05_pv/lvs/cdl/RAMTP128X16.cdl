* 
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
* 
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Two Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.589um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 16 -b\
* Configuration: mux off -bus_notation on -check_instname on -diode\
* Configuration: s on -drive 6 -ema on -frequency 1.0 -instname RAM\
* Configuration: TP128X16 -left_bus_delim "[" -mux 2 -mvt "" -name_\
* Configuration: case upper -power_type otc -prefix "" -pwr_gnd_ren\
* Configuration: ame vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention o\
* Configuration: n -right_bus_delim "]" -ser none -site_def off -to\
* Configuration: p_layer m5-m10 -words 128 -write_mask on -corners \
* Configuration: ff_1p10v_1p10v_0c,ff_1p10v_1p10v_125c,ff_1p10v_1p1\
* Configuration: 0v_m40c,ff_1p21v_1p21v_0c,ff_1p21v_1p21v_125c,ff_1\
* Configuration: p21v_1p21v_m40c,ff_1p26v_1p26v_0c,ff_1p26v_1p26v_1\
* Configuration: 25c,ff_1p26v_1p26v_85c,ff_1p26v_1p26v_m40c,ss_0p90\
* Configuration: v_0p90v_0c,ss_0p90v_0p90v_125c,ss_0p90v_0p90v_m40c\
* Configuration: ,ss_0p99v_0p99v_0c,ss_0p99v_0p99v_125c,ss_0p99v_0p\
* Configuration: 99v_m40c,ss_1p08v_1p08v_0c,ss_1p08v_1p08v_125c,ss_\
* Configuration: 1p08v_1p08v_m40c,tt_1p00v_1p00v_125c,tt_1p00v_1p00\
* Configuration: v_25c,tt_1p00v_1p00v_85c,tt_1p10v_1p10v_125c,tt_1p\
* Configuration: 10v_1p10v_25c,tt_1p10v_1p10v_85c,tt_1p20v_1p20v_12\
* Configuration: 5c,tt_1p20v_1p20v_25c,tt_1p20v_1p20v_85c
* Codefile: 
* 
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RAMTP128X16WD32X2 DBLA DBLA_DUMO DBLA_OUT DBLA_UP DBLB DWLA DWLB
+  EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1
+  LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A LOG1B N0A N0B N1A N1B
+  N2A N2B N3A N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4
+  NXAP0_5 NXAP0_6 NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5
+  NXAP1_6 NXAP1_7 NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6
+  NXBP0_7 NXBP1_0 NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7
+  RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A
+  ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0
+  VDDC_FDECA1 VDDC_FDECB0 VDDC_FDECB1 VDDC_WLA0 VDDC_WLA1 VDDC_WLB0 VDDC_WLB1
+  VDDPE VDDP_WDA VDDP_WDB VNWC VNWP VPW VSS VSSE WLA0 WLA1 WLA2 WLA3 WLA4
+  WLA5 WLA6 WLA7 WLA8 WLA9 WLA10 WLA11 WLA12 WLA13 WLA14 WLA15 WLA16 WLA17
+  WLA18 WLA19 WLA20 WLA21 WLA22 WLA23 WLA24 WLA25 WLA26 WLA27 WLA28 WLA29
+  WLA30 WLA31 WLB0 WLB1 WLB2 WLB3 WLB4 WLB5 WLB6 WLB7 WLB8 WLB9 WLB10 WLB11
+  WLB12 WLB13 WLB14 WLB15 WLB16 WLB17 WLB18 WLB19 WLB20 WLB21 WLB22 WLB23
+  WLB24 WLB25 WLB26 WLB27 WLB28 WLB29 WLB30 WLB31
** RAMTP128X16WD32X2: 1211 flat devices **
X_MI1.I8.MX_npd I1.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI1.I8._nr.MXNA1 I1.ROWSELA NXAP0_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8._nr.MXNA2 I1.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I8._nr.MXPA1 I1.ROWSELA NXAP0_0 I1.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I8._nr.MXPA2 I1.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I9.MX_npd I1.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI1.I9._nr.MXNA1 I1.ROWSELB NXBP0_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9._nr.MXNA2 I1.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1.I9._nr.MXPA1 I1.ROWSELB NXBP0_0 I1.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1.I9._nr.MXPA2 I1.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI1._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwla0.MXN11 WLA2 I1._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwla0.MXN8 I1._DRVWLA0.NWL I1.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwla0.MXP12 I1._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwla0.MXP13 I1._DRVWLA0.NWL I1.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwla0.MXP7 WLA2 I1._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwla1.MXN11 WLA3 I1._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwla1.MXN8 I1._DRVWLA1.NWL I1.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwla1.MXP12 I1._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwla1.MXP13 I1._DRVWLA1.NWL I1.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwla1.MXP7 WLA3 I1._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwlb0.MXN11 WLB2 I1._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwlb0.MXN8 I1._DRVWLB0.NWL I1.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwlb0.MXP12 I1._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwlb0.MXP13 I1._DRVWLB0.NWL I1.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwlb0.MXP7 WLB2 I1._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI1._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI1._drvwlb1.MXN11 WLB3 I1._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI1._drvwlb1.MXN8 I1._DRVWLB1.NWL I1.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI1._drvwlb1.MXP12 I1._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI1._drvwlb1.MXP13 I1._DRVWLB1.NWL I1.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI1._drvwlb1.MXP7 WLB3 I1._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI2.I8.MX_npd I2.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI2.I8._nr.MXNA1 I2.ROWSELA NXAP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8._nr.MXNA2 I2.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I8._nr.MXPA1 I2.ROWSELA NXAP0_1 I2.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I8._nr.MXPA2 I2.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I9.MX_npd I2.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI2.I9._nr.MXNA1 I2.ROWSELB NXBP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9._nr.MXNA2 I2.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2.I9._nr.MXPA1 I2.ROWSELB NXBP0_1 I2.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2.I9._nr.MXPA2 I2.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI2._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwla0.MXN11 WLA4 I2._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwla0.MXN8 I2._DRVWLA0.NWL I2.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwla0.MXP12 I2._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwla0.MXP13 I2._DRVWLA0.NWL I2.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwla0.MXP7 WLA4 I2._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwla1.MXN11 WLA5 I2._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwla1.MXN8 I2._DRVWLA1.NWL I2.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwla1.MXP12 I2._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwla1.MXP13 I2._DRVWLA1.NWL I2.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwla1.MXP7 WLA5 I2._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwlb0.MXN11 WLB4 I2._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwlb0.MXN8 I2._DRVWLB0.NWL I2.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwlb0.MXP12 I2._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwlb0.MXP13 I2._DRVWLB0.NWL I2.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwlb0.MXP7 WLB4 I2._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI2._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI2._drvwlb1.MXN11 WLB5 I2._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI2._drvwlb1.MXN8 I2._DRVWLB1.NWL I2.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI2._drvwlb1.MXP12 I2._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI2._drvwlb1.MXP13 I2._DRVWLB1.NWL I2.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI2._drvwlb1.MXP7 WLB5 I2._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI20_0.MXNA1 ILAA[0] NLAA[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI20_0.MXPA1 ILAA[0] NLAA[0] VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_MI20_1.MXNA1 ILAA[1] NLAA[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI20_1.MXPA1 ILAA[1] NLAA[1] VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_MI21_0.MXNA1 IRAA[0] NRAA[0] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_0.MXPA1 IRAA[0] NRAA[0] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI21_1.MXNA1 IRAA[1] NRAA[1] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_1.MXPA1 IRAA[1] NRAA[1] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI21_2.MXNA1 IRAA[2] NRAA[2] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI21_2.MXPA1 IRAA[2] NRAA[2] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI22_0.MXNA1 NRAA[0] RAA[0] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_0.MXPA1 NRAA[0] RAA[0] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI22_1.MXNA1 NRAA[1] RAA[1] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_1.MXPA1 NRAA[1] RAA[1] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI22_2.MXNA1 NRAA[2] RAA[2] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI22_2.MXPA1 NRAA[2] RAA[2] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_0.MXNA1 NRAA[3] RAA[3] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_0.MXPA1 NRAA[3] RAA[3] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_1.MXNA1 NRAA[4] RAA[4] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_1.MXPA1 NRAA[4] RAA[4] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI23_2.MXNA1 NRAA[5] RAA[5] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI23_2.MXPA1 NRAA[5] RAA[5] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI24_0.MXNA1 IRAA[3] NRAA[3] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_0.MXPA1 IRAA[3] NRAA[3] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI24_1.MXNA1 IRAA[4] NRAA[4] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_1.MXPA1 IRAA[4] NRAA[4] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI24_2.MXNA1 IRAA[5] NRAA[5] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI24_2.MXPA1 IRAA[5] NRAA[5] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_0.MXNA1 IRAB[3] NRAB[3] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_0.MXPA1 IRAB[3] NRAB[3] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_1.MXNA1 IRAB[4] NRAB[4] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_1.MXPA1 IRAB[4] NRAB[4] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI25_2.MXNA1 IRAB[5] NRAB[5] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI25_2.MXPA1 IRAB[5] NRAB[5] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI26_0.MXNA1 NRAB[3] RAB[3] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_0.MXPA1 NRAB[3] RAB[3] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI26_1.MXNA1 NRAB[4] RAB[4] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_1.MXPA1 NRAB[4] RAB[4] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI26_2.MXNA1 NRAB[5] RAB[5] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI26_2.MXPA1 NRAB[5] RAB[5] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_0.MXNA1 NRAB[0] RAB[0] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_0.MXPA1 NRAB[0] RAB[0] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_1.MXNA1 NRAB[1] RAB[1] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_1.MXPA1 NRAB[1] RAB[1] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI27_2.MXNA1 NRAB[2] RAB[2] VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI27_2.MXPA1 NRAB[2] RAB[2] VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_MI28_0.MXNA1 IRAB[0] NRAB[0] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_0.MXPA1 IRAB[0] NRAB[0] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI28_1.MXNA1 IRAB[1] NRAB[1] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_1.MXPA1 IRAB[1] NRAB[1] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI28_2.MXNA1 IRAB[2] NRAB[2] VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI28_2.MXPA1 IRAB[2] NRAB[2] VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_MI29_0.MXNA1 ILAB[0] NLAB[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI29_0.MXPA1 ILAB[0] NLAB[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI29_1.MXNA1 ILAB[1] NLAB[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI29_1.MXPA1 ILAB[1] NLAB[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI3.I8.MX_npd I3.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI3.I8._nr.MXNA1 I3.ROWSELA NXAP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8._nr.MXNA2 I3.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I8._nr.MXPA1 I3.ROWSELA NXAP0_1 I3.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I8._nr.MXPA2 I3.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I9.MX_npd I3.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI3.I9._nr.MXNA1 I3.ROWSELB NXBP0_1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9._nr.MXNA2 I3.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3.I9._nr.MXPA1 I3.ROWSELB NXBP0_1 I3.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3.I9._nr.MXPA2 I3.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI3._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwla0.MXN11 WLA6 I3._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwla0.MXN8 I3._DRVWLA0.NWL I3.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwla0.MXP12 I3._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwla0.MXP13 I3._DRVWLA0.NWL I3.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwla0.MXP7 WLA6 I3._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwla1.MXN11 WLA7 I3._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwla1.MXN8 I3._DRVWLA1.NWL I3.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwla1.MXP12 I3._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwla1.MXP13 I3._DRVWLA1.NWL I3.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwla1.MXP7 WLA7 I3._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwlb0.MXN11 WLB6 I3._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwlb0.MXN8 I3._DRVWLB0.NWL I3.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwlb0.MXP12 I3._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwlb0.MXP13 I3._DRVWLB0.NWL I3.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwlb0.MXP7 WLB6 I3._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI3._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI3._drvwlb1.MXN11 WLB7 I3._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI3._drvwlb1.MXN8 I3._DRVWLB1.NWL I3.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI3._drvwlb1.MXP12 I3._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI3._drvwlb1.MXP13 I3._DRVWLB1.NWL I3.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI3._drvwlb1.MXP7 WLB7 I3._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI30_0.MXNA1 NLAB[0] LAB[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI30_0.MXPA1 NLAB[0] LAB[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI30_1.MXNA1 NLAB[1] LAB[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI30_1.MXPA1 NLAB[1] LAB[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI35.I8.MX_npd I35.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI35.I8._nr.MXNA1 I35.ROWSELA NXAP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8._nr.MXNA2 I35.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I8._nr.MXPA1 I35.ROWSELA NXAP0_4 I35.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I8._nr.MXPA2 I35.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I9.MX_npd I35.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI35.I9._nr.MXNA1 I35.ROWSELB NXBP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9._nr.MXNA2 I35.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35.I9._nr.MXPA1 I35.ROWSELB NXBP0_4 I35.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35.I9._nr.MXPA2 I35.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI35._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwla0.MXN11 WLA16 I35._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwla0.MXN8 I35._DRVWLA0.NWL I35.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwla0.MXP12 I35._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwla0.MXP13 I35._DRVWLA0.NWL I35.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwla0.MXP7 WLA16 I35._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwla1.MXN11 WLA17 I35._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwla1.MXN8 I35._DRVWLA1.NWL I35.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwla1.MXP12 I35._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwla1.MXP13 I35._DRVWLA1.NWL I35.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwla1.MXP7 WLA17 I35._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwlb0.MXN11 WLB16 I35._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwlb0.MXN8 I35._DRVWLB0.NWL I35.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwlb0.MXP12 I35._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwlb0.MXP13 I35._DRVWLB0.NWL I35.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwlb0.MXP7 WLB16 I35._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI35._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI35._drvwlb1.MXN11 WLB17 I35._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI35._drvwlb1.MXN8 I35._DRVWLB1.NWL I35.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI35._drvwlb1.MXP12 I35._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI35._drvwlb1.MXP13 I35._DRVWLB1.NWL I35.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI35._drvwlb1.MXP7 WLB17 I35._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36.I8.MX_npd I36.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI36.I8._nr.MXNA1 I36.ROWSELA NXAP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8._nr.MXNA2 I36.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I8._nr.MXPA1 I36.ROWSELA NXAP0_4 I36.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I8._nr.MXPA2 I36.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I9.MX_npd I36.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI36.I9._nr.MXNA1 I36.ROWSELB NXBP0_4 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9._nr.MXNA2 I36.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36.I9._nr.MXPA1 I36.ROWSELB NXBP0_4 I36.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36.I9._nr.MXPA2 I36.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI36._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwla0.MXN11 WLA18 I36._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwla0.MXN8 I36._DRVWLA0.NWL I36.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwla0.MXP12 I36._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwla0.MXP13 I36._DRVWLA0.NWL I36.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwla0.MXP7 WLA18 I36._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwla1.MXN11 WLA19 I36._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwla1.MXN8 I36._DRVWLA1.NWL I36.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwla1.MXP12 I36._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwla1.MXP13 I36._DRVWLA1.NWL I36.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwla1.MXP7 WLA19 I36._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwlb0.MXN11 WLB18 I36._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwlb0.MXN8 I36._DRVWLB0.NWL I36.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwlb0.MXP12 I36._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwlb0.MXP13 I36._DRVWLB0.NWL I36.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwlb0.MXP7 WLB18 I36._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI36._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI36._drvwlb1.MXN11 WLB19 I36._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI36._drvwlb1.MXN8 I36._DRVWLB1.NWL I36.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI36._drvwlb1.MXP12 I36._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI36._drvwlb1.MXP13 I36._DRVWLB1.NWL I36.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI36._drvwlb1.MXP7 WLB19 I36._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI4.I8.MX_npd I4.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI4.I8._nr.MXNA1 I4.ROWSELA NXAP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8._nr.MXNA2 I4.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I8._nr.MXPA1 I4.ROWSELA NXAP0_2 I4.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I8._nr.MXPA2 I4.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I9.MX_npd I4.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI4.I9._nr.MXNA1 I4.ROWSELB NXBP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9._nr.MXNA2 I4.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4.I9._nr.MXPA1 I4.ROWSELB NXBP0_2 I4.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4.I9._nr.MXPA2 I4.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI4._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwla0.MXN11 WLA8 I4._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwla0.MXN8 I4._DRVWLA0.NWL I4.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwla0.MXP12 I4._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwla0.MXP13 I4._DRVWLA0.NWL I4.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwla0.MXP7 WLA8 I4._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwla1.MXN11 WLA9 I4._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwla1.MXN8 I4._DRVWLA1.NWL I4.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwla1.MXP12 I4._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwla1.MXP13 I4._DRVWLA1.NWL I4.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwla1.MXP7 WLA9 I4._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwlb0.MXN11 WLB8 I4._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwlb0.MXN8 I4._DRVWLB0.NWL I4.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwlb0.MXP12 I4._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwlb0.MXP13 I4._DRVWLB0.NWL I4.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwlb0.MXP7 WLB8 I4._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U L=0.04U
X_MI4._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI4._drvwlb1.MXN11 WLB9 I4._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI4._drvwlb1.MXN8 I4._DRVWLB1.NWL I4.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI4._drvwlb1.MXP12 I4._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI4._drvwlb1.MXP13 I4._DRVWLB1.NWL I4.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI4._drvwlb1.MXP7 WLB9 I4._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U L=0.04U
X_MI40.I8.MX_npd I40.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI40.I8._nr.MXNA1 I40.ROWSELA NXAP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8._nr.MXNA2 I40.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I8._nr.MXPA1 I40.ROWSELA NXAP0_5 I40.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I8._nr.MXPA2 I40.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I9.MX_npd I40.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI40.I9._nr.MXNA1 I40.ROWSELB NXBP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9._nr.MXNA2 I40.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40.I9._nr.MXPA1 I40.ROWSELB NXBP0_5 I40.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40.I9._nr.MXPA2 I40.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI40._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwla0.MXN11 WLA20 I40._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwla0.MXN8 I40._DRVWLA0.NWL I40.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwla0.MXP12 I40._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwla0.MXP13 I40._DRVWLA0.NWL I40.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwla0.MXP7 WLA20 I40._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwla1.MXN11 WLA21 I40._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwla1.MXN8 I40._DRVWLA1.NWL I40.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwla1.MXP12 I40._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwla1.MXP13 I40._DRVWLA1.NWL I40.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwla1.MXP7 WLA21 I40._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwlb0.MXN11 WLB20 I40._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwlb0.MXN8 I40._DRVWLB0.NWL I40.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwlb0.MXP12 I40._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwlb0.MXP13 I40._DRVWLB0.NWL I40.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwlb0.MXP7 WLB20 I40._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI40._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI40._drvwlb1.MXN11 WLB21 I40._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI40._drvwlb1.MXN8 I40._DRVWLB1.NWL I40.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI40._drvwlb1.MXP12 I40._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI40._drvwlb1.MXP13 I40._DRVWLB1.NWL I40.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI40._drvwlb1.MXP7 WLB21 I40._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42.I8.MX_npd I42.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI42.I8._nr.MXNA1 I42.ROWSELA NXAP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8._nr.MXNA2 I42.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I8._nr.MXPA1 I42.ROWSELA NXAP0_5 I42.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I8._nr.MXPA2 I42.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I9.MX_npd I42.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI42.I9._nr.MXNA1 I42.ROWSELB NXBP0_5 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9._nr.MXNA2 I42.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42.I9._nr.MXPA1 I42.ROWSELB NXBP0_5 I42.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42.I9._nr.MXPA2 I42.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI42._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwla0.MXN11 WLA22 I42._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwla0.MXN8 I42._DRVWLA0.NWL I42.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwla0.MXP12 I42._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwla0.MXP13 I42._DRVWLA0.NWL I42.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwla0.MXP7 WLA22 I42._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwla1.MXN11 WLA23 I42._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwla1.MXN8 I42._DRVWLA1.NWL I42.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwla1.MXP12 I42._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwla1.MXP13 I42._DRVWLA1.NWL I42.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwla1.MXP7 WLA23 I42._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwlb0.MXN11 WLB22 I42._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwlb0.MXN8 I42._DRVWLB0.NWL I42.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwlb0.MXP12 I42._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwlb0.MXP13 I42._DRVWLB0.NWL I42.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwlb0.MXP7 WLB22 I42._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI42._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI42._drvwlb1.MXN11 WLB23 I42._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI42._drvwlb1.MXN8 I42._DRVWLB1.NWL I42.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI42._drvwlb1.MXP12 I42._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI42._drvwlb1.MXP13 I42._DRVWLB1.NWL I42.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI42._drvwlb1.MXP7 WLB23 I42._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43.I8.MX_npd I43.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI43.I8._nr.MXNA1 I43.ROWSELA NXAP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8._nr.MXNA2 I43.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I8._nr.MXPA1 I43.ROWSELA NXAP0_6 I43.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I8._nr.MXPA2 I43.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I9.MX_npd I43.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI43.I9._nr.MXNA1 I43.ROWSELB NXBP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9._nr.MXNA2 I43.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43.I9._nr.MXPA1 I43.ROWSELB NXBP0_6 I43.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43.I9._nr.MXPA2 I43.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI43._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwla0.MXN11 WLA24 I43._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwla0.MXN8 I43._DRVWLA0.NWL I43.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwla0.MXP12 I43._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwla0.MXP13 I43._DRVWLA0.NWL I43.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwla0.MXP7 WLA24 I43._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwla1.MXN11 WLA25 I43._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwla1.MXN8 I43._DRVWLA1.NWL I43.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwla1.MXP12 I43._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwla1.MXP13 I43._DRVWLA1.NWL I43.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwla1.MXP7 WLA25 I43._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwlb0.MXN11 WLB24 I43._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwlb0.MXN8 I43._DRVWLB0.NWL I43.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwlb0.MXP12 I43._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwlb0.MXP13 I43._DRVWLB0.NWL I43.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwlb0.MXP7 WLB24 I43._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI43._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI43._drvwlb1.MXN11 WLB25 I43._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI43._drvwlb1.MXN8 I43._DRVWLB1.NWL I43.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI43._drvwlb1.MXP12 I43._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI43._drvwlb1.MXP13 I43._DRVWLB1.NWL I43.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI43._drvwlb1.MXP7 WLB25 I43._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44.I8.MX_npd I44.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI44.I8._nr.MXNA1 I44.ROWSELA NXAP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8._nr.MXNA2 I44.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I8._nr.MXPA1 I44.ROWSELA NXAP0_6 I44.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I8._nr.MXPA2 I44.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I9.MX_npd I44.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI44.I9._nr.MXNA1 I44.ROWSELB NXBP0_6 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9._nr.MXNA2 I44.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44.I9._nr.MXPA1 I44.ROWSELB NXBP0_6 I44.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44.I9._nr.MXPA2 I44.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI44._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwla0.MXN11 WLA26 I44._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwla0.MXN8 I44._DRVWLA0.NWL I44.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwla0.MXP12 I44._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwla0.MXP13 I44._DRVWLA0.NWL I44.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwla0.MXP7 WLA26 I44._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwla1.MXN11 WLA27 I44._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwla1.MXN8 I44._DRVWLA1.NWL I44.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwla1.MXP12 I44._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwla1.MXP13 I44._DRVWLA1.NWL I44.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwla1.MXP7 WLA27 I44._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwlb0.MXN11 WLB26 I44._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwlb0.MXN8 I44._DRVWLB0.NWL I44.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwlb0.MXP12 I44._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwlb0.MXP13 I44._DRVWLB0.NWL I44.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwlb0.MXP7 WLB26 I44._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI44._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI44._drvwlb1.MXN11 WLB27 I44._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI44._drvwlb1.MXN8 I44._DRVWLB1.NWL I44.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI44._drvwlb1.MXP12 I44._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI44._drvwlb1.MXP13 I44._DRVWLB1.NWL I44.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI44._drvwlb1.MXP7 WLB27 I44._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45.I8.MX_npd I45.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI45.I8._nr.MXNA1 I45.ROWSELA NXAP0_7 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8._nr.MXNA2 I45.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I8._nr.MXPA1 I45.ROWSELA NXAP0_7 I45.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I8._nr.MXPA2 I45.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I9.MX_npd I45.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI45.I9._nr.MXNA1 I45.ROWSELB NXBP0_7 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9._nr.MXNA2 I45.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45.I9._nr.MXPA1 I45.ROWSELB NXBP0_7 I45.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45.I9._nr.MXPA2 I45.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI45._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwla0.MXN11 WLA28 I45._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwla0.MXN8 I45._DRVWLA0.NWL I45.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwla0.MXP12 I45._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwla0.MXP13 I45._DRVWLA0.NWL I45.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwla0.MXP7 WLA28 I45._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwla1.MXN11 WLA29 I45._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwla1.MXN8 I45._DRVWLA1.NWL I45.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwla1.MXP12 I45._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwla1.MXP13 I45._DRVWLA1.NWL I45.ROWSELA VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwla1.MXP7 WLA29 I45._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwlb0.MXN11 WLB28 I45._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwlb0.MXN8 I45._DRVWLB0.NWL I45.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwlb0.MXP12 I45._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwlb0.MXP13 I45._DRVWLB0.NWL I45.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwlb0.MXP7 WLB28 I45._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI45._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI45._drvwlb1.MXN11 WLB29 I45._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U
+  L=0.04U
X_MI45._drvwlb1.MXN8 I45._DRVWLB1.NWL I45.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI45._drvwlb1.MXP12 I45._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI45._drvwlb1.MXP13 I45._DRVWLB1.NWL I45.ROWSELB VDDCE VNWC P11LL_CKT
+  W=0.37U L=0.04U
X_MI45._drvwlb1.MXP7 WLB29 I45._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5.I8.MX_npd I5.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI5.I8._nr.MXNA1 I5.ROWSELA NXAP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8._nr.MXNA2 I5.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I8._nr.MXPA1 I5.ROWSELA NXAP0_2 I5.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I8._nr.MXPA2 I5.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I9.MX_npd I5.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI5.I9._nr.MXNA1 I5.ROWSELB NXBP0_2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9._nr.MXNA2 I5.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5.I9._nr.MXPA1 I5.ROWSELB NXBP0_2 I5.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5.I9._nr.MXPA2 I5.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI5._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwla0.MXN11 WLA10 I5._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwla0.MXN8 I5._DRVWLA0.NWL I5.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwla0.MXP12 I5._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwla0.MXP13 I5._DRVWLA0.NWL I5.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwla0.MXP7 WLA10 I5._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwla1.MXN11 WLA11 I5._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwla1.MXN8 I5._DRVWLA1.NWL I5.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwla1.MXP12 I5._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwla1.MXP13 I5._DRVWLA1.NWL I5.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwla1.MXP7 WLA11 I5._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwlb0.MXN11 WLB10 I5._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwlb0.MXN8 I5._DRVWLB0.NWL I5.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwlb0.MXP12 I5._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwlb0.MXP13 I5._DRVWLB0.NWL I5.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwlb0.MXP7 WLB10 I5._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI5._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI5._drvwlb1.MXN11 WLB11 I5._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI5._drvwlb1.MXN8 I5._DRVWLB1.NWL I5.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI5._drvwlb1.MXP12 I5._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI5._drvwlb1.MXP13 I5._DRVWLB1.NWL I5.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI5._drvwlb1.MXP7 WLB11 I5._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6.I8.MX_npd I6.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI6.I8._nr.MXNA1 I6.ROWSELA NXAP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8._nr.MXNA2 I6.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I8._nr.MXPA1 I6.ROWSELA NXAP0_3 I6.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I8._nr.MXPA2 I6.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I9.MX_npd I6.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI6.I9._nr.MXNA1 I6.ROWSELB NXBP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9._nr.MXNA2 I6.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6.I9._nr.MXPA1 I6.ROWSELB NXBP0_3 I6.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6.I9._nr.MXPA2 I6.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI6._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwla0.MXN11 WLA12 I6._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwla0.MXN8 I6._DRVWLA0.NWL I6.ROWSELA N0A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwla0.MXP12 I6._DRVWLA0.NWL ROWCLK0A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwla0.MXP13 I6._DRVWLA0.NWL I6.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwla0.MXP7 WLA12 I6._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwla1.MXN11 WLA13 I6._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwla1.MXN8 I6._DRVWLA1.NWL I6.ROWSELA N1A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwla1.MXP12 I6._DRVWLA1.NWL ROWCLK1A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwla1.MXP13 I6._DRVWLA1.NWL I6.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwla1.MXP7 WLA13 I6._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwlb0.MXN11 WLB12 I6._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwlb0.MXN8 I6._DRVWLB0.NWL I6.ROWSELB N0B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwlb0.MXP12 I6._DRVWLB0.NWL ROWCLK0B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwlb0.MXP13 I6._DRVWLB0.NWL I6.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwlb0.MXP7 WLB12 I6._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI6._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI6._drvwlb1.MXN11 WLB13 I6._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI6._drvwlb1.MXN8 I6._DRVWLB1.NWL I6.ROWSELB N1B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI6._drvwlb1.MXP12 I6._DRVWLB1.NWL ROWCLK1B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI6._drvwlb1.MXP13 I6._DRVWLB1.NWL I6.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI6._drvwlb1.MXP7 WLB13 I6._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI69.MXN3 VSSE DBLA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXN4 NET510 I69.NDI VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXN8 I69.NDI DBLA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI69.MXP0 I69.NDI DBLA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI69.MXP1 NET510 I69.NDI VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI69.MXP2 NET510 I69.NDI VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI7.I8.MX_npd I7.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI7.I8._nr.MXNA1 I7.ROWSELA NXAP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8._nr.MXNA2 I7.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I8._nr.MXPA1 I7.ROWSELA NXAP0_3 I7.I8._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I8._nr.MXPA2 I7.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I9.MX_npd I7.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI7.I9._nr.MXNA1 I7.ROWSELB NXBP0_3 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9._nr.MXNA2 I7.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.I9._nr.MXPA1 I7.ROWSELB NXBP0_3 I7.I9._NR.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7.I9._nr.MXPA2 I7.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI7._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwla0.MXN11 WLA14 I7._DRVWLA0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwla0.MXN8 I7._DRVWLA0.NWL I7.ROWSELA N2A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwla0.MXP12 I7._DRVWLA0.NWL ROWCLK2A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwla0.MXP13 I7._DRVWLA0.NWL I7.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwla0.MXP7 WLA14 I7._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwla1.MXN11 WLA15 I7._DRVWLA1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwla1.MXN8 I7._DRVWLA1.NWL I7.ROWSELA N3A VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwla1.MXP12 I7._DRVWLA1.NWL ROWCLK3A VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwla1.MXP13 I7._DRVWLA1.NWL I7.ROWSELA VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwla1.MXP7 WLA15 I7._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwlb0.MXN11 WLB14 I7._DRVWLB0.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwlb0.MXN8 I7._DRVWLB0.NWL I7.ROWSELB N2B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwlb0.MXP12 I7._DRVWLB0.NWL ROWCLK2B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwlb0.MXP13 I7._DRVWLB0.NWL I7.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwlb0.MXP7 WLB14 I7._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI7._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI7._drvwlb1.MXN11 WLB15 I7._DRVWLB1.NWL VSSE VPW N11LL_CKT W=4.84U L=0.04U
X_MI7._drvwlb1.MXN8 I7._DRVWLB1.NWL I7.ROWSELB N3B VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MI7._drvwlb1.MXP12 I7._DRVWLB1.NWL ROWCLK3B VDDCE VNWC P11LL_CKT W=1.18U
+  L=0.04U
X_MI7._drvwlb1.MXP13 I7._DRVWLB1.NWL I7.ROWSELB VDDCE VNWC P11LL_CKT W=0.37U
+  L=0.04U
X_MI7._drvwlb1.MXP7 WLB15 I7._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT W=7U
+  L=0.04U
X_MI70.MXN3 I70.NDI NET510 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI70.MXN4 DBLA_DUMO I70.NDI VSSE VPW N11LL_CKT W=0.62U L=0.04U
X_MI70.MXN8 I70.NDI NET510 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI70.MXP0 I70.NDI NET510 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI70.MXP1 DBLA_DUMO I70.NDI VDDPE VNWP P11LL_CKT W=0.62U L=0.04U
X_MI70.MXP2 DBLA_DUMO I70.NDI VDDPE VNWP P11LL_CKT W=0.62U L=0.04U
X_MXP2 DBLA_UP DWLA VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_dummy_txa_0.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_0.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_1.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txa_1.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_0.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_0.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_1.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dummy_txb_1.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_lainv_0.MXNA1 NLAA[0] LAA[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_lainv_0.MXPA1 NLAA[0] LAA[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_lainv_1.MXNA1 NLAA[1] LAA[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_lainv_1.MXPA1 NLAA[1] LAA[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_mem_dbla.I2.MXNA1 _MEM_DBLA.NSEL0 EMAA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I2.MXNA2 _MEM_DBLA.NSEL0 EMAA[0] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I2.MXPA1 _MEM_DBLA.NSEL0 EMAA[2] _MEM_DBLA.I2.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.I2.MXPA2 _MEM_DBLA.I2.P1 EMAA[0] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dbla.I73.MXNA1 _MEM_DBLA.NIDBL DBLA VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_M_mem_dbla.I73.MXPA1 _MEM_DBLA.NIDBL DBLA VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dbla.I77.MXNA1 _MEM_DBLA.NSEL1 EMAA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I77.MXNA2 _MEM_DBLA.NSEL1 EMAA[1] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dbla.I77.MXPA1 _MEM_DBLA.NSEL1 EMAA[2] _MEM_DBLA.I77.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.I77.MXPA2 _MEM_DBLA.I77.P1 EMAA[1] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dbla.MXN19 DBLA DWLA _MEM_DBLA.IA[0] VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN20 _MEM_DBLA.IA[0] LOG1A VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN21 VSSE LOG1A VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dbla.MXN22 DBLA DWLA _MEM_DBLA.IA[1] VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dbla.MXN23 _MEM_DBLA.IA[1] _MEM_DBLA.NSEL0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_mem_dbla.MXN24 VSSE LOG1A VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dbla.MXN25 DBLA DWLA _MEM_DBLA.IA[2] VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dbla.MXN26 _MEM_DBLA.IA[2] _MEM_DBLA.NSEL1 VSSE VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_mem_dbla.MXN27 VSSE LOG1A VSSE VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dbla.MXN28 DBLA DWLA _MEM_DBLA.IA[3] VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dbla.MXN29 _MEM_DBLA.IA[3] _MEM_DBLA.NSEL1 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dbla.MXN30 VSSE _MEM_DBLA.NSEL0 VSSE VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dbla.MXP10 _MEM_DBLA.NET53 _MEM_DBLA.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dbla.MXP12 DBLA DWLA VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_mem_dbla.MXP7 _MEM_DBLA.NET057 _MEM_DBLA.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.245U L=0.04U
X_M_mem_dbla.MXP8 DBLA LOG1A _MEM_DBLA.NET057 VNWP P11LL_CKT W=0.245U L=0.04U
X_M_mem_dbla.MXP9 DBLA LOG1A _MEM_DBLA.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_mem_dblb.I2.MXNA1 _MEM_DBLB.NSEL0 EMAB[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I2.MXNA2 _MEM_DBLB.NSEL0 EMAB[0] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I2.MXPA1 _MEM_DBLB.NSEL0 EMAB[2] _MEM_DBLB.I2.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.I2.MXPA2 _MEM_DBLB.I2.P1 EMAB[0] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dblb.I73.MXNA1 _MEM_DBLB.NIDBL DBLB VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_M_mem_dblb.I73.MXPA1 _MEM_DBLB.NIDBL DBLB VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dblb.I77.MXNA1 _MEM_DBLB.NSEL1 EMAB[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I77.MXNA2 _MEM_DBLB.NSEL1 EMAB[1] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_mem_dblb.I77.MXPA1 _MEM_DBLB.NSEL1 EMAB[2] _MEM_DBLB.I77.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.I77.MXPA2 _MEM_DBLB.I77.P1 EMAB[1] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_mem_dblb.MXN19 DBLB DWLB _MEM_DBLB.IA[0] VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN20 _MEM_DBLB.IA[0] LOG1B VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN21 VSSE LOG1B VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_M_mem_dblb.MXN22 DBLB DWLB _MEM_DBLB.IA[1] VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dblb.MXN23 _MEM_DBLB.IA[1] _MEM_DBLB.NSEL0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_mem_dblb.MXN24 VSSE LOG1B VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_mem_dblb.MXN25 DBLB DWLB _MEM_DBLB.IA[2] VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dblb.MXN26 _MEM_DBLB.IA[2] _MEM_DBLB.NSEL1 VSSE VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_mem_dblb.MXN27 VSSE LOG1B VSSE VPW N11LL_CKT W=0.37U L=0.04U
X_M_mem_dblb.MXN28 DBLB DWLB _MEM_DBLB.IA[3] VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dblb.MXN29 _MEM_DBLB.IA[3] _MEM_DBLB.NSEL1 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_mem_dblb.MXN30 VSSE _MEM_DBLB.NSEL0 VSSE VPW N11LL_CKT W=0.17U L=0.04U
X_M_mem_dblb.MXP10 _MEM_DBLB.NET53 _MEM_DBLB.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_mem_dblb.MXP12 DBLB DWLB VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_mem_dblb.MXP7 _MEM_DBLB.NET057 _MEM_DBLB.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_mem_dblb.MXP8 DBLB LOG1B _MEM_DBLB.NET057 VNWP P11LL_CKT W=0.25U L=0.04U
X_M_mem_dblb.MXP9 DBLB LOG1B _MEM_DBLB.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_rowcka.I0_0.MXNA1 _ROWCKA.NDEC[0] NLAA[0] _ROWCKA.I0_0.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_0.MXNA2 _ROWCKA.I0_0.N1 NLAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_0.MXPA1 _ROWCKA.NDEC[0] NLAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_0.MXPA2 _ROWCKA.NDEC[0] NLAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_1.MXNA1 _ROWCKA.NDEC[1] ILAA[0] _ROWCKA.I0_1.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_1.MXNA2 _ROWCKA.I0_1.N1 NLAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_1.MXPA1 _ROWCKA.NDEC[1] ILAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_1.MXPA2 _ROWCKA.NDEC[1] NLAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_2.MXNA1 _ROWCKA.NDEC[2] NLAA[0] _ROWCKA.I0_2.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_2.MXNA2 _ROWCKA.I0_2.N1 ILAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_2.MXPA1 _ROWCKA.NDEC[2] NLAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_2.MXPA2 _ROWCKA.NDEC[2] ILAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_3.MXNA1 _ROWCKA.NDEC[3] ILAA[0] _ROWCKA.I0_3.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowcka.I0_3.MXNA2 _ROWCKA.I0_3.N1 ILAA[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowcka.I0_3.MXPA1 _ROWCKA.NDEC[3] ILAA[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I0_3.MXPA2 _ROWCKA.NDEC[3] ILAA[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowcka.I1_0.MXNA1 ROWEN0A _ROWCKA.NDEC[0] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_0.MXPA1 ROWEN0A _ROWCKA.NDEC[0] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_1.MXNA1 ROWEN1A _ROWCKA.NDEC[1] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_1.MXPA1 ROWEN1A _ROWCKA.NDEC[1] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_2.MXNA1 ROWEN2A _ROWCKA.NDEC[2] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_2.MXPA1 ROWEN2A _ROWCKA.NDEC[2] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowcka.I1_3.MXNA1 ROWEN3A _ROWCKA.NDEC[3] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowcka.I1_3.MXPA1 ROWEN3A _ROWCKA.NDEC[3] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I0_0.MXNA1 _ROWCKB.NDEC[0] NLAB[0] _ROWCKB.I0_0.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_0.MXNA2 _ROWCKB.I0_0.N1 NLAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_0.MXPA1 _ROWCKB.NDEC[0] NLAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_0.MXPA2 _ROWCKB.NDEC[0] NLAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_1.MXNA1 _ROWCKB.NDEC[1] ILAB[0] _ROWCKB.I0_1.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_1.MXNA2 _ROWCKB.I0_1.N1 NLAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_1.MXPA1 _ROWCKB.NDEC[1] ILAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_1.MXPA2 _ROWCKB.NDEC[1] NLAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_2.MXNA1 _ROWCKB.NDEC[2] NLAB[0] _ROWCKB.I0_2.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_2.MXNA2 _ROWCKB.I0_2.N1 ILAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_2.MXPA1 _ROWCKB.NDEC[2] NLAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_2.MXPA2 _ROWCKB.NDEC[2] ILAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_3.MXNA1 _ROWCKB.NDEC[3] ILAB[0] _ROWCKB.I0_3.N1 VPW N11LL_CKT
+  W=0.37U L=0.04U
X_M_rowckb.I0_3.MXNA2 _ROWCKB.I0_3.N1 ILAB[1] VSS VPW N11LL_CKT W=0.37U
+  L=0.04U
X_M_rowckb.I0_3.MXPA1 _ROWCKB.NDEC[3] ILAB[0] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I0_3.MXPA2 _ROWCKB.NDEC[3] ILAB[1] VDDPE VNWP P11LL_CKT W=0.54U
+  L=0.04U
X_M_rowckb.I1_0.MXNA1 ROWEN0B _ROWCKB.NDEC[0] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_0.MXPA1 ROWEN0B _ROWCKB.NDEC[0] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_1.MXNA1 ROWEN1B _ROWCKB.NDEC[1] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_1.MXPA1 ROWEN1B _ROWCKB.NDEC[1] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_2.MXNA1 ROWEN2B _ROWCKB.NDEC[2] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_2.MXPA1 ROWEN2B _ROWCKB.NDEC[2] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowckb.I1_3.MXNA1 ROWEN3B _ROWCKB.NDEC[3] VSS VPW N11LL_CKT W=0.57U
+  L=0.04U
X_M_rowckb.I1_3.MXPA1 ROWEN3B _ROWCKB.NDEC[3] VDDPE VNWP P11LL_CKT W=1.02U
+  L=0.04U
X_M_rowdrva_0_2_0.I2.MXNA1 _ROWDRVA_0_2_0.NROWCLK GTPA0 _ROWDRVA_0_2_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_0_2_0.I2.MXNA2 _ROWDRVA_0_2_0.I2.N1 ROWEN0A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_0_2_0.I2.MXPA1 _ROWDRVA_0_2_0.NROWCLK GTPA0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_0_2_0.I2.MXPA2 _ROWDRVA_0_2_0.NROWCLK ROWEN0A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_0_2_0.IV_RdWrClk.MXNA1 ROWCLK0A _ROWDRVA_0_2_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_0_2_0.IV_RdWrClk.MXPA1 ROWCLK0A _ROWDRVA_0_2_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_0_2_0.MXN0 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_0_2_0.MXP2 N0A ROWCLK0A VDDC_FDECA0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_0_2_1.I2.MXNA1 _ROWDRVA_0_2_1.NROWCLK GTPA0 _ROWDRVA_0_2_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_0_2_1.I2.MXNA2 _ROWDRVA_0_2_1.I2.N1 ROWEN2A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_0_2_1.I2.MXPA1 _ROWDRVA_0_2_1.NROWCLK GTPA0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_0_2_1.I2.MXPA2 _ROWDRVA_0_2_1.NROWCLK ROWEN2A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_0_2_1.IV_RdWrClk.MXNA1 ROWCLK2A _ROWDRVA_0_2_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_0_2_1.IV_RdWrClk.MXPA1 ROWCLK2A _ROWDRVA_0_2_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_0_2_1.MXN0 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_0_2_1.MXP2 N2A ROWCLK2A VDDC_FDECA0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_1_3_0.I2.MXNA1 _ROWDRVA_1_3_0.NROWCLK GTPA1 _ROWDRVA_1_3_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_1_3_0.I2.MXNA2 _ROWDRVA_1_3_0.I2.N1 ROWEN1A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_1_3_0.I2.MXPA1 _ROWDRVA_1_3_0.NROWCLK GTPA1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_1_3_0.I2.MXPA2 _ROWDRVA_1_3_0.NROWCLK ROWEN1A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_1_3_0.IV_RdWrClk.MXNA1 ROWCLK1A _ROWDRVA_1_3_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_1_3_0.IV_RdWrClk.MXPA1 ROWCLK1A _ROWDRVA_1_3_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_1_3_0.MXN0 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_1_3_0.MXP2 N1A ROWCLK1A VDDC_FDECA1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrva_1_3_1.I2.MXNA1 _ROWDRVA_1_3_1.NROWCLK GTPA1 _ROWDRVA_1_3_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrva_1_3_1.I2.MXNA2 _ROWDRVA_1_3_1.I2.N1 ROWEN3A VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrva_1_3_1.I2.MXPA1 _ROWDRVA_1_3_1.NROWCLK GTPA1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrva_1_3_1.I2.MXPA2 _ROWDRVA_1_3_1.NROWCLK ROWEN3A VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrva_1_3_1.IV_RdWrClk.MXNA1 ROWCLK3A _ROWDRVA_1_3_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrva_1_3_1.IV_RdWrClk.MXPA1 ROWCLK3A _ROWDRVA_1_3_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrva_1_3_1.MXN0 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrva_1_3_1.MXP2 N3A ROWCLK3A VDDC_FDECA1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_0_2_0.I2.MXNA1 _ROWDRVB_0_2_0.NROWCLK GTPB0 _ROWDRVB_0_2_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXNA2 _ROWDRVB_0_2_0.I2.N1 ROWEN0B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXPA1 _ROWDRVB_0_2_0.NROWCLK GTPB0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_0_2_0.I2.MXPA2 _ROWDRVB_0_2_0.NROWCLK ROWEN0B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_0_2_0.IV_RdWrClk.MXNA1 ROWCLK0B _ROWDRVB_0_2_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_0_2_0.IV_RdWrClk.MXPA1 ROWCLK0B _ROWDRVB_0_2_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_0_2_0.MXN0 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_0_2_0.MXP2 N0B ROWCLK0B VDDC_FDECB0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_0_2_1.I2.MXNA1 _ROWDRVB_0_2_1.NROWCLK GTPB0 _ROWDRVB_0_2_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXNA2 _ROWDRVB_0_2_1.I2.N1 ROWEN2B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXPA1 _ROWDRVB_0_2_1.NROWCLK GTPB0 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_0_2_1.I2.MXPA2 _ROWDRVB_0_2_1.NROWCLK ROWEN2B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_0_2_1.IV_RdWrClk.MXNA1 ROWCLK2B _ROWDRVB_0_2_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_0_2_1.IV_RdWrClk.MXPA1 ROWCLK2B _ROWDRVB_0_2_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_0_2_1.MXN0 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_0_2_1.MXP2 N2B ROWCLK2B VDDC_FDECB0 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_1_3_0.I2.MXNA1 _ROWDRVB_1_3_0.NROWCLK GTPB1 _ROWDRVB_1_3_0.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXNA2 _ROWDRVB_1_3_0.I2.N1 ROWEN1B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXPA1 _ROWDRVB_1_3_0.NROWCLK GTPB1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_1_3_0.I2.MXPA2 _ROWDRVB_1_3_0.NROWCLK ROWEN1B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_1_3_0.IV_RdWrClk.MXNA1 ROWCLK1B _ROWDRVB_1_3_0.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_1_3_0.IV_RdWrClk.MXPA1 ROWCLK1B _ROWDRVB_1_3_0.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_1_3_0.MXN0 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_1_3_0.MXP2 N1B ROWCLK1B VDDC_FDECB1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_rowdrvb_1_3_1.I2.MXNA1 _ROWDRVB_1_3_1.NROWCLK GTPB1 _ROWDRVB_1_3_1.I2.N1
+  VPW N11LL_CKT W=2.5U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXNA2 _ROWDRVB_1_3_1.I2.N1 ROWEN3B VSS VPW N11LL_CKT
+  W=3.11U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXPA1 _ROWDRVB_1_3_1.NROWCLK GTPB1 VDDPE VNWP P11LL_CKT
+  W=2.13U L=0.04U
X_M_rowdrvb_1_3_1.I2.MXPA2 _ROWDRVB_1_3_1.NROWCLK ROWEN3B VDDPE VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_rowdrvb_1_3_1.IV_RdWrClk.MXNA1 ROWCLK3B _ROWDRVB_1_3_1.NROWCLK VSSE VPW
+  N11LL_CKT W=4.5U L=0.04U
X_M_rowdrvb_1_3_1.IV_RdWrClk.MXPA1 ROWCLK3B _ROWDRVB_1_3_1.NROWCLK VDDPE VNWP
+  P11LL_CKT W=8.2U L=0.04U
X_M_rowdrvb_1_3_1.MXN0 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_rowdrvb_1_3_1.MXP2 N3B ROWCLK3B VDDC_FDECB1 VNWC P11LL_CKT W=1.785U
+  L=0.04U
X_M_wd_base_bot.I8.MX_npd _WD_BASE_BOT.ROWSELA RETA VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_bot.I8._nr.MXNA1 _WD_BASE_BOT.ROWSELA NXAP0_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8._nr.MXNA2 _WD_BASE_BOT.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I8._nr.MXPA1 _WD_BASE_BOT.ROWSELA NXAP0_0
+  _WD_BASE_BOT.I8._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I8._nr.MXPA2 _WD_BASE_BOT.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I9.MX_npd _WD_BASE_BOT.ROWSELB RETB VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_bot.I9._nr.MXNA1 _WD_BASE_BOT.ROWSELB NXBP0_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9._nr.MXNA2 _WD_BASE_BOT.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_bot.I9._nr.MXPA1 _WD_BASE_BOT.ROWSELB NXBP0_0
+  _WD_BASE_BOT.I9._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot.I9._nr.MXPA2 _WD_BASE_BOT.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_bot._drvwla0.MXN10 N0A ROWCLK0A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwla0.MXN11 WLA0 _WD_BASE_BOT._DRVWLA0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwla0.MXN8 _WD_BASE_BOT._DRVWLA0.NWL _WD_BASE_BOT.ROWSELA
+  N0A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwla0.MXP12 _WD_BASE_BOT._DRVWLA0.NWL ROWCLK0A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwla0.MXP13 _WD_BASE_BOT._DRVWLA0.NWL _WD_BASE_BOT.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwla0.MXP7 WLA0 _WD_BASE_BOT._DRVWLA0.NWL VDDC_WLA0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwla1.MXN10 N1A ROWCLK1A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwla1.MXN11 WLA1 _WD_BASE_BOT._DRVWLA1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwla1.MXN8 _WD_BASE_BOT._DRVWLA1.NWL _WD_BASE_BOT.ROWSELA
+  N1A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwla1.MXP12 _WD_BASE_BOT._DRVWLA1.NWL ROWCLK1A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwla1.MXP13 _WD_BASE_BOT._DRVWLA1.NWL _WD_BASE_BOT.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwla1.MXP7 WLA1 _WD_BASE_BOT._DRVWLA1.NWL VDDC_WLA1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwlb0.MXN10 N0B ROWCLK0B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwlb0.MXN11 WLB0 _WD_BASE_BOT._DRVWLB0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwlb0.MXN8 _WD_BASE_BOT._DRVWLB0.NWL _WD_BASE_BOT.ROWSELB
+  N0B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP12 _WD_BASE_BOT._DRVWLB0.NWL ROWCLK0B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP13 _WD_BASE_BOT._DRVWLB0.NWL _WD_BASE_BOT.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwlb0.MXP7 WLB0 _WD_BASE_BOT._DRVWLB0.NWL VDDC_WLB0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_bot._drvwlb1.MXN10 N1B ROWCLK1B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_bot._drvwlb1.MXN11 WLB1 _WD_BASE_BOT._DRVWLB1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_bot._drvwlb1.MXN8 _WD_BASE_BOT._DRVWLB1.NWL _WD_BASE_BOT.ROWSELB
+  N1B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP12 _WD_BASE_BOT._DRVWLB1.NWL ROWCLK1B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP13 _WD_BASE_BOT._DRVWLB1.NWL _WD_BASE_BOT.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_bot._drvwlb1.MXP7 WLB1 _WD_BASE_BOT._DRVWLB1.NWL VDDC_WLB1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top.I8.MX_npd _WD_BASE_TOP.ROWSELA RETA VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_top.I8._nr.MXNA1 _WD_BASE_TOP.ROWSELA NXAP0_7 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8._nr.MXNA2 _WD_BASE_TOP.ROWSELA NXAP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I8._nr.MXPA1 _WD_BASE_TOP.ROWSELA NXAP0_7
+  _WD_BASE_TOP.I8._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I8._nr.MXPA2 _WD_BASE_TOP.I8._NR.P1 NXAP1_0 VDDP_WDA VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I9.MX_npd _WD_BASE_TOP.ROWSELB RETB VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base_top.I9._nr.MXNA1 _WD_BASE_TOP.ROWSELB NXBP0_7 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9._nr.MXNA2 _WD_BASE_TOP.ROWSELB NXBP1_0 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_wd_base_top.I9._nr.MXPA1 _WD_BASE_TOP.ROWSELB NXBP0_7
+  _WD_BASE_TOP.I9._NR.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top.I9._nr.MXPA2 _WD_BASE_TOP.I9._NR.P1 NXBP1_0 VDDP_WDB VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base_top._drvwla0.MXN10 N2A ROWCLK2A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwla0.MXN11 WLA30 _WD_BASE_TOP._DRVWLA0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwla0.MXN8 _WD_BASE_TOP._DRVWLA0.NWL _WD_BASE_TOP.ROWSELA
+  N2A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwla0.MXP12 _WD_BASE_TOP._DRVWLA0.NWL ROWCLK2A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwla0.MXP13 _WD_BASE_TOP._DRVWLA0.NWL _WD_BASE_TOP.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwla0.MXP7 WLA30 _WD_BASE_TOP._DRVWLA0.NWL VDDC_WLA0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwla1.MXN10 N3A ROWCLK3A VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwla1.MXN11 WLA31 _WD_BASE_TOP._DRVWLA1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwla1.MXN8 _WD_BASE_TOP._DRVWLA1.NWL _WD_BASE_TOP.ROWSELA
+  N3A VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwla1.MXP12 _WD_BASE_TOP._DRVWLA1.NWL ROWCLK3A VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwla1.MXP13 _WD_BASE_TOP._DRVWLA1.NWL _WD_BASE_TOP.ROWSELA
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwla1.MXP7 WLA31 _WD_BASE_TOP._DRVWLA1.NWL VDDC_WLA1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwlb0.MXN10 N2B ROWCLK2B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwlb0.MXN11 WLB30 _WD_BASE_TOP._DRVWLB0.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwlb0.MXN8 _WD_BASE_TOP._DRVWLB0.NWL _WD_BASE_TOP.ROWSELB
+  N2B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwlb0.MXP12 _WD_BASE_TOP._DRVWLB0.NWL ROWCLK2B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwlb0.MXP13 _WD_BASE_TOP._DRVWLB0.NWL _WD_BASE_TOP.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwlb0.MXP7 WLB30 _WD_BASE_TOP._DRVWLB0.NWL VDDC_WLB0 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_base_top._drvwlb1.MXN10 N3B ROWCLK3B VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base_top._drvwlb1.MXN11 WLB31 _WD_BASE_TOP._DRVWLB1.NWL VSSE VPW
+  N11LL_CKT W=4.84U L=0.04U
X_M_wd_base_top._drvwlb1.MXN8 _WD_BASE_TOP._DRVWLB1.NWL _WD_BASE_TOP.ROWSELB
+  N3B VPW N11LL_CKT W=1.99U L=0.04U
X_M_wd_base_top._drvwlb1.MXP12 _WD_BASE_TOP._DRVWLB1.NWL ROWCLK3B VDDCE VNWC
+  P11LL_CKT W=1.18U L=0.04U
X_M_wd_base_top._drvwlb1.MXP13 _WD_BASE_TOP._DRVWLB1.NWL _WD_BASE_TOP.ROWSELB
+  VDDCE VNWC P11LL_CKT W=0.37U L=0.04U
X_M_wd_base_top._drvwlb1.MXP7 WLB31 _WD_BASE_TOP._DRVWLB1.NWL VDDC_WLB1 VNWC
+  P11LL_CKT W=7U L=0.04U
X_M_wd_dp299_dbla_0.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_0.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_1.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_1.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_10.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_10.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_11.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_11.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_12.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_12.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_13.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_13.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_14.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_14.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_15.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_15.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_2.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_2.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_3.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_3.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_4.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_4.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_5.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_5.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_6.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_6.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_7.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_7.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_8.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_8.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_9.MXNpg_0 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dbla_9.MXNpg_1 DBLA LOG0_DWLA DBLA VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_0.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_0.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_1.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_1.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_10.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_10.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_11.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_11.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_12.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_12.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_13.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_13.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_14.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_14.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_15.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_15.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_2.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_2.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_3.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_3.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_4.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_4.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_5.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_5.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_6.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_6.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_7.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_7.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_8.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_8.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_9.MXNpg_0 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_wd_dp299_dblb_9.MXNpg_1 DBLB LOG0_DWLB DBLB VPW N11LL_CKT W=0.14U L=0.04U
X_M_xp0a._dec.I1_0.MXNA1 _XP0A._DEC.NDEC[0] NRAA[0] _XP0A._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_0.MXNA2 _XP0A._DEC.I1_0.N2 NRAA[1] _XP0A._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_0.MXNA3 _XP0A._DEC.I1_0.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_0.MXPA1 _XP0A._DEC.NDEC[0] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_0.MXPA2 _XP0A._DEC.NDEC[0] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_0.MXPA3 _XP0A._DEC.NDEC[0] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXNA1 _XP0A._DEC.NDEC[1] IRAA[0] _XP0A._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_1.MXNA2 _XP0A._DEC.I1_1.N2 NRAA[1] _XP0A._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_1.MXNA3 _XP0A._DEC.I1_1.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_1.MXPA1 _XP0A._DEC.NDEC[1] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXPA2 _XP0A._DEC.NDEC[1] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_1.MXPA3 _XP0A._DEC.NDEC[1] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXNA1 _XP0A._DEC.NDEC[2] NRAA[0] _XP0A._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_2.MXNA2 _XP0A._DEC.I1_2.N2 IRAA[1] _XP0A._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_2.MXNA3 _XP0A._DEC.I1_2.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_2.MXPA1 _XP0A._DEC.NDEC[2] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXPA2 _XP0A._DEC.NDEC[2] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_2.MXPA3 _XP0A._DEC.NDEC[2] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXNA1 _XP0A._DEC.NDEC[3] IRAA[0] _XP0A._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_3.MXNA2 _XP0A._DEC.I1_3.N2 IRAA[1] _XP0A._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_3.MXNA3 _XP0A._DEC.I1_3.N1 NRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_3.MXPA1 _XP0A._DEC.NDEC[3] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXPA2 _XP0A._DEC.NDEC[3] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_3.MXPA3 _XP0A._DEC.NDEC[3] NRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXNA1 _XP0A._DEC.NDEC[4] NRAA[0] _XP0A._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_4.MXNA2 _XP0A._DEC.I1_4.N2 NRAA[1] _XP0A._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_4.MXNA3 _XP0A._DEC.I1_4.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_4.MXPA1 _XP0A._DEC.NDEC[4] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXPA2 _XP0A._DEC.NDEC[4] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_4.MXPA3 _XP0A._DEC.NDEC[4] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXNA1 _XP0A._DEC.NDEC[5] IRAA[0] _XP0A._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_5.MXNA2 _XP0A._DEC.I1_5.N2 NRAA[1] _XP0A._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_5.MXNA3 _XP0A._DEC.I1_5.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_5.MXPA1 _XP0A._DEC.NDEC[5] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXPA2 _XP0A._DEC.NDEC[5] NRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_5.MXPA3 _XP0A._DEC.NDEC[5] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXNA1 _XP0A._DEC.NDEC[6] NRAA[0] _XP0A._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_6.MXNA2 _XP0A._DEC.I1_6.N2 IRAA[1] _XP0A._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_6.MXNA3 _XP0A._DEC.I1_6.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_6.MXPA1 _XP0A._DEC.NDEC[6] NRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXPA2 _XP0A._DEC.NDEC[6] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_6.MXPA3 _XP0A._DEC.NDEC[6] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXNA1 _XP0A._DEC.NDEC[7] IRAA[0] _XP0A._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_7.MXNA2 _XP0A._DEC.I1_7.N2 IRAA[1] _XP0A._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0a._dec.I1_7.MXNA3 _XP0A._DEC.I1_7.N1 IRAA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0a._dec.I1_7.MXPA1 _XP0A._DEC.NDEC[7] IRAA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXPA2 _XP0A._DEC.NDEC[7] IRAA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I1_7.MXPA3 _XP0A._DEC.NDEC[7] IRAA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0a._dec.I3_0.MXNA1 _XP0A.XP[0] _XP0A._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_0.MXPA1 _XP0A.XP[0] _XP0A._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_1.MXNA1 _XP0A.XP[1] _XP0A._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_1.MXPA1 _XP0A.XP[1] _XP0A._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_2.MXNA1 _XP0A.XP[2] _XP0A._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_2.MXPA1 _XP0A.XP[2] _XP0A._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_3.MXNA1 _XP0A.XP[3] _XP0A._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_3.MXPA1 _XP0A.XP[3] _XP0A._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_4.MXNA1 _XP0A.XP[4] _XP0A._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_4.MXPA1 _XP0A.XP[4] _XP0A._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_5.MXNA1 _XP0A.XP[5] _XP0A._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_5.MXPA1 _XP0A.XP[5] _XP0A._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_6.MXNA1 _XP0A.XP[6] _XP0A._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_6.MXPA1 _XP0A.XP[6] _XP0A._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._dec.I3_7.MXNA1 _XP0A.XP[7] _XP0A._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0a._dec.I3_7.MXPA1 _XP0A.XP[7] _XP0A._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0a._iv_nxp_0.MXNA1 NXAP0_0 _XP0A.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_0.MXPA1 NXAP0_0 _XP0A.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_1.MXNA1 NXAP0_1 _XP0A.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_1.MXPA1 NXAP0_1 _XP0A.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_2.MXNA1 NXAP0_2 _XP0A.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_2.MXPA1 NXAP0_2 _XP0A.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_3.MXNA1 NXAP0_3 _XP0A.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_3.MXPA1 NXAP0_3 _XP0A.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_4.MXNA1 NXAP0_4 _XP0A.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_4.MXPA1 NXAP0_4 _XP0A.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_5.MXNA1 NXAP0_5 _XP0A.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_5.MXPA1 NXAP0_5 _XP0A.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_6.MXNA1 NXAP0_6 _XP0A.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_6.MXPA1 NXAP0_6 _XP0A.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0a._iv_nxp_7.MXNA1 NXAP0_7 _XP0A.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0a._iv_nxp_7.MXPA1 NXAP0_7 _XP0A.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._dec.I1_0.MXNA1 _XP0B._DEC.NDEC[0] NRAB[0] _XP0B._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_0.MXNA2 _XP0B._DEC.I1_0.N2 NRAB[1] _XP0B._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_0.MXNA3 _XP0B._DEC.I1_0.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_0.MXPA1 _XP0B._DEC.NDEC[0] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_0.MXPA2 _XP0B._DEC.NDEC[0] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_0.MXPA3 _XP0B._DEC.NDEC[0] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXNA1 _XP0B._DEC.NDEC[1] IRAB[0] _XP0B._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_1.MXNA2 _XP0B._DEC.I1_1.N2 NRAB[1] _XP0B._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_1.MXNA3 _XP0B._DEC.I1_1.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_1.MXPA1 _XP0B._DEC.NDEC[1] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXPA2 _XP0B._DEC.NDEC[1] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_1.MXPA3 _XP0B._DEC.NDEC[1] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXNA1 _XP0B._DEC.NDEC[2] NRAB[0] _XP0B._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_2.MXNA2 _XP0B._DEC.I1_2.N2 IRAB[1] _XP0B._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_2.MXNA3 _XP0B._DEC.I1_2.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_2.MXPA1 _XP0B._DEC.NDEC[2] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXPA2 _XP0B._DEC.NDEC[2] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_2.MXPA3 _XP0B._DEC.NDEC[2] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXNA1 _XP0B._DEC.NDEC[3] IRAB[0] _XP0B._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_3.MXNA2 _XP0B._DEC.I1_3.N2 IRAB[1] _XP0B._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_3.MXNA3 _XP0B._DEC.I1_3.N1 NRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_3.MXPA1 _XP0B._DEC.NDEC[3] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXPA2 _XP0B._DEC.NDEC[3] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_3.MXPA3 _XP0B._DEC.NDEC[3] NRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXNA1 _XP0B._DEC.NDEC[4] NRAB[0] _XP0B._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_4.MXNA2 _XP0B._DEC.I1_4.N2 NRAB[1] _XP0B._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_4.MXNA3 _XP0B._DEC.I1_4.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_4.MXPA1 _XP0B._DEC.NDEC[4] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXPA2 _XP0B._DEC.NDEC[4] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_4.MXPA3 _XP0B._DEC.NDEC[4] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXNA1 _XP0B._DEC.NDEC[5] IRAB[0] _XP0B._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_5.MXNA2 _XP0B._DEC.I1_5.N2 NRAB[1] _XP0B._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_5.MXNA3 _XP0B._DEC.I1_5.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_5.MXPA1 _XP0B._DEC.NDEC[5] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXPA2 _XP0B._DEC.NDEC[5] NRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_5.MXPA3 _XP0B._DEC.NDEC[5] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXNA1 _XP0B._DEC.NDEC[6] NRAB[0] _XP0B._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_6.MXNA2 _XP0B._DEC.I1_6.N2 IRAB[1] _XP0B._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_6.MXNA3 _XP0B._DEC.I1_6.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_6.MXPA1 _XP0B._DEC.NDEC[6] NRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXPA2 _XP0B._DEC.NDEC[6] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_6.MXPA3 _XP0B._DEC.NDEC[6] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXNA1 _XP0B._DEC.NDEC[7] IRAB[0] _XP0B._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_7.MXNA2 _XP0B._DEC.I1_7.N2 IRAB[1] _XP0B._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp0b._dec.I1_7.MXNA3 _XP0B._DEC.I1_7.N1 IRAB[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp0b._dec.I1_7.MXPA1 _XP0B._DEC.NDEC[7] IRAB[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXPA2 _XP0B._DEC.NDEC[7] IRAB[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I1_7.MXPA3 _XP0B._DEC.NDEC[7] IRAB[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp0b._dec.I3_0.MXNA1 _XP0B.XP[0] _XP0B._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_0.MXPA1 _XP0B.XP[0] _XP0B._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_1.MXNA1 _XP0B.XP[1] _XP0B._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_1.MXPA1 _XP0B.XP[1] _XP0B._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_2.MXNA1 _XP0B.XP[2] _XP0B._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_2.MXPA1 _XP0B.XP[2] _XP0B._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_3.MXNA1 _XP0B.XP[3] _XP0B._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_3.MXPA1 _XP0B.XP[3] _XP0B._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_4.MXNA1 _XP0B.XP[4] _XP0B._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_4.MXPA1 _XP0B.XP[4] _XP0B._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_5.MXNA1 _XP0B.XP[5] _XP0B._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_5.MXPA1 _XP0B.XP[5] _XP0B._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_6.MXNA1 _XP0B.XP[6] _XP0B._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_6.MXPA1 _XP0B.XP[6] _XP0B._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._dec.I3_7.MXNA1 _XP0B.XP[7] _XP0B._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp0b._dec.I3_7.MXPA1 _XP0B.XP[7] _XP0B._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp0b._iv_nxp_0.MXNA1 NXBP0_0 _XP0B.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_0.MXPA1 NXBP0_0 _XP0B.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_1.MXNA1 NXBP0_1 _XP0B.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_1.MXPA1 NXBP0_1 _XP0B.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_2.MXNA1 NXBP0_2 _XP0B.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_2.MXPA1 NXBP0_2 _XP0B.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_3.MXNA1 NXBP0_3 _XP0B.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_3.MXPA1 NXBP0_3 _XP0B.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_4.MXNA1 NXBP0_4 _XP0B.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_4.MXPA1 NXBP0_4 _XP0B.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_5.MXNA1 NXBP0_5 _XP0B.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_5.MXPA1 NXBP0_5 _XP0B.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_6.MXNA1 NXBP0_6 _XP0B.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_6.MXPA1 NXBP0_6 _XP0B.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp0b._iv_nxp_7.MXNA1 NXBP0_7 _XP0B.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp0b._iv_nxp_7.MXPA1 NXBP0_7 _XP0B.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._dec.I1_0.MXNA1 _XP1A._DEC.NDEC[0] NRAA[3] _XP1A._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_0.MXNA2 _XP1A._DEC.I1_0.N2 NRAA[4] _XP1A._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_0.MXNA3 _XP1A._DEC.I1_0.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_0.MXPA1 _XP1A._DEC.NDEC[0] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_0.MXPA2 _XP1A._DEC.NDEC[0] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_0.MXPA3 _XP1A._DEC.NDEC[0] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXNA1 _XP1A._DEC.NDEC[1] IRAA[3] _XP1A._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_1.MXNA2 _XP1A._DEC.I1_1.N2 NRAA[4] _XP1A._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_1.MXNA3 _XP1A._DEC.I1_1.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_1.MXPA1 _XP1A._DEC.NDEC[1] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXPA2 _XP1A._DEC.NDEC[1] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_1.MXPA3 _XP1A._DEC.NDEC[1] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXNA1 _XP1A._DEC.NDEC[2] NRAA[3] _XP1A._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_2.MXNA2 _XP1A._DEC.I1_2.N2 IRAA[4] _XP1A._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_2.MXNA3 _XP1A._DEC.I1_2.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_2.MXPA1 _XP1A._DEC.NDEC[2] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXPA2 _XP1A._DEC.NDEC[2] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_2.MXPA3 _XP1A._DEC.NDEC[2] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXNA1 _XP1A._DEC.NDEC[3] IRAA[3] _XP1A._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_3.MXNA2 _XP1A._DEC.I1_3.N2 IRAA[4] _XP1A._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_3.MXNA3 _XP1A._DEC.I1_3.N1 NRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_3.MXPA1 _XP1A._DEC.NDEC[3] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXPA2 _XP1A._DEC.NDEC[3] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_3.MXPA3 _XP1A._DEC.NDEC[3] NRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXNA1 _XP1A._DEC.NDEC[4] NRAA[3] _XP1A._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_4.MXNA2 _XP1A._DEC.I1_4.N2 NRAA[4] _XP1A._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_4.MXNA3 _XP1A._DEC.I1_4.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_4.MXPA1 _XP1A._DEC.NDEC[4] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXPA2 _XP1A._DEC.NDEC[4] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_4.MXPA3 _XP1A._DEC.NDEC[4] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXNA1 _XP1A._DEC.NDEC[5] IRAA[3] _XP1A._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_5.MXNA2 _XP1A._DEC.I1_5.N2 NRAA[4] _XP1A._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_5.MXNA3 _XP1A._DEC.I1_5.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_5.MXPA1 _XP1A._DEC.NDEC[5] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXPA2 _XP1A._DEC.NDEC[5] NRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_5.MXPA3 _XP1A._DEC.NDEC[5] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXNA1 _XP1A._DEC.NDEC[6] NRAA[3] _XP1A._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_6.MXNA2 _XP1A._DEC.I1_6.N2 IRAA[4] _XP1A._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_6.MXNA3 _XP1A._DEC.I1_6.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_6.MXPA1 _XP1A._DEC.NDEC[6] NRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXPA2 _XP1A._DEC.NDEC[6] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_6.MXPA3 _XP1A._DEC.NDEC[6] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXNA1 _XP1A._DEC.NDEC[7] IRAA[3] _XP1A._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_7.MXNA2 _XP1A._DEC.I1_7.N2 IRAA[4] _XP1A._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1a._dec.I1_7.MXNA3 _XP1A._DEC.I1_7.N1 IRAA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1a._dec.I1_7.MXPA1 _XP1A._DEC.NDEC[7] IRAA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXPA2 _XP1A._DEC.NDEC[7] IRAA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I1_7.MXPA3 _XP1A._DEC.NDEC[7] IRAA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1a._dec.I3_0.MXNA1 _XP1A.XP[0] _XP1A._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_0.MXPA1 _XP1A.XP[0] _XP1A._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_1.MXNA1 _XP1A.XP[1] _XP1A._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_1.MXPA1 _XP1A.XP[1] _XP1A._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_2.MXNA1 _XP1A.XP[2] _XP1A._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_2.MXPA1 _XP1A.XP[2] _XP1A._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_3.MXNA1 _XP1A.XP[3] _XP1A._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_3.MXPA1 _XP1A.XP[3] _XP1A._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_4.MXNA1 _XP1A.XP[4] _XP1A._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_4.MXPA1 _XP1A.XP[4] _XP1A._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_5.MXNA1 _XP1A.XP[5] _XP1A._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_5.MXPA1 _XP1A.XP[5] _XP1A._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_6.MXNA1 _XP1A.XP[6] _XP1A._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_6.MXPA1 _XP1A.XP[6] _XP1A._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._dec.I3_7.MXNA1 _XP1A.XP[7] _XP1A._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1a._dec.I3_7.MXPA1 _XP1A.XP[7] _XP1A._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1a._iv_nxp_0.MXNA1 NXAP1_0 _XP1A.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_0.MXPA1 NXAP1_0 _XP1A.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_1.MXNA1 NXAP1_1 _XP1A.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_1.MXPA1 NXAP1_1 _XP1A.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_2.MXNA1 NXAP1_2 _XP1A.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_2.MXPA1 NXAP1_2 _XP1A.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_3.MXNA1 NXAP1_3 _XP1A.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_3.MXPA1 NXAP1_3 _XP1A.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_4.MXNA1 NXAP1_4 _XP1A.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_4.MXPA1 NXAP1_4 _XP1A.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_5.MXNA1 NXAP1_5 _XP1A.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_5.MXPA1 NXAP1_5 _XP1A.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_6.MXNA1 NXAP1_6 _XP1A.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_6.MXPA1 NXAP1_6 _XP1A.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1a._iv_nxp_7.MXNA1 NXAP1_7 _XP1A.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1a._iv_nxp_7.MXPA1 NXAP1_7 _XP1A.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._dec.I1_0.MXNA1 _XP1B._DEC.NDEC[0] NRAB[3] _XP1B._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_0.MXNA2 _XP1B._DEC.I1_0.N2 NRAB[4] _XP1B._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_0.MXNA3 _XP1B._DEC.I1_0.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_0.MXPA1 _XP1B._DEC.NDEC[0] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_0.MXPA2 _XP1B._DEC.NDEC[0] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_0.MXPA3 _XP1B._DEC.NDEC[0] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXNA1 _XP1B._DEC.NDEC[1] IRAB[3] _XP1B._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_1.MXNA2 _XP1B._DEC.I1_1.N2 NRAB[4] _XP1B._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_1.MXNA3 _XP1B._DEC.I1_1.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_1.MXPA1 _XP1B._DEC.NDEC[1] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXPA2 _XP1B._DEC.NDEC[1] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_1.MXPA3 _XP1B._DEC.NDEC[1] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXNA1 _XP1B._DEC.NDEC[2] NRAB[3] _XP1B._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_2.MXNA2 _XP1B._DEC.I1_2.N2 IRAB[4] _XP1B._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_2.MXNA3 _XP1B._DEC.I1_2.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_2.MXPA1 _XP1B._DEC.NDEC[2] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXPA2 _XP1B._DEC.NDEC[2] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_2.MXPA3 _XP1B._DEC.NDEC[2] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXNA1 _XP1B._DEC.NDEC[3] IRAB[3] _XP1B._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_3.MXNA2 _XP1B._DEC.I1_3.N2 IRAB[4] _XP1B._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_3.MXNA3 _XP1B._DEC.I1_3.N1 NRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_3.MXPA1 _XP1B._DEC.NDEC[3] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXPA2 _XP1B._DEC.NDEC[3] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_3.MXPA3 _XP1B._DEC.NDEC[3] NRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXNA1 _XP1B._DEC.NDEC[4] NRAB[3] _XP1B._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_4.MXNA2 _XP1B._DEC.I1_4.N2 NRAB[4] _XP1B._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_4.MXNA3 _XP1B._DEC.I1_4.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_4.MXPA1 _XP1B._DEC.NDEC[4] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXPA2 _XP1B._DEC.NDEC[4] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_4.MXPA3 _XP1B._DEC.NDEC[4] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXNA1 _XP1B._DEC.NDEC[5] IRAB[3] _XP1B._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_5.MXNA2 _XP1B._DEC.I1_5.N2 NRAB[4] _XP1B._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_5.MXNA3 _XP1B._DEC.I1_5.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_5.MXPA1 _XP1B._DEC.NDEC[5] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXPA2 _XP1B._DEC.NDEC[5] NRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_5.MXPA3 _XP1B._DEC.NDEC[5] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXNA1 _XP1B._DEC.NDEC[6] NRAB[3] _XP1B._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_6.MXNA2 _XP1B._DEC.I1_6.N2 IRAB[4] _XP1B._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_6.MXNA3 _XP1B._DEC.I1_6.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_6.MXPA1 _XP1B._DEC.NDEC[6] NRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXPA2 _XP1B._DEC.NDEC[6] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_6.MXPA3 _XP1B._DEC.NDEC[6] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXNA1 _XP1B._DEC.NDEC[7] IRAB[3] _XP1B._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_7.MXNA2 _XP1B._DEC.I1_7.N2 IRAB[4] _XP1B._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xp1b._dec.I1_7.MXNA3 _XP1B._DEC.I1_7.N1 IRAB[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xp1b._dec.I1_7.MXPA1 _XP1B._DEC.NDEC[7] IRAB[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXPA2 _XP1B._DEC.NDEC[7] IRAB[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I1_7.MXPA3 _XP1B._DEC.NDEC[7] IRAB[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xp1b._dec.I3_0.MXNA1 _XP1B.XP[0] _XP1B._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_0.MXPA1 _XP1B.XP[0] _XP1B._DEC.NDEC[0] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_1.MXNA1 _XP1B.XP[1] _XP1B._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_1.MXPA1 _XP1B.XP[1] _XP1B._DEC.NDEC[1] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_2.MXNA1 _XP1B.XP[2] _XP1B._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_2.MXPA1 _XP1B.XP[2] _XP1B._DEC.NDEC[2] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_3.MXNA1 _XP1B.XP[3] _XP1B._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_3.MXPA1 _XP1B.XP[3] _XP1B._DEC.NDEC[3] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_4.MXNA1 _XP1B.XP[4] _XP1B._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_4.MXPA1 _XP1B.XP[4] _XP1B._DEC.NDEC[4] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_5.MXNA1 _XP1B.XP[5] _XP1B._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_5.MXPA1 _XP1B.XP[5] _XP1B._DEC.NDEC[5] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_6.MXNA1 _XP1B.XP[6] _XP1B._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_6.MXPA1 _XP1B.XP[6] _XP1B._DEC.NDEC[6] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._dec.I3_7.MXNA1 _XP1B.XP[7] _XP1B._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xp1b._dec.I3_7.MXPA1 _XP1B.XP[7] _XP1B._DEC.NDEC[7] VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_xp1b._iv_nxp_0.MXNA1 NXBP1_0 _XP1B.XP[0] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_0.MXPA1 NXBP1_0 _XP1B.XP[0] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_1.MXNA1 NXBP1_1 _XP1B.XP[1] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_1.MXPA1 NXBP1_1 _XP1B.XP[1] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_2.MXNA1 NXBP1_2 _XP1B.XP[2] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_2.MXPA1 NXBP1_2 _XP1B.XP[2] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_3.MXNA1 NXBP1_3 _XP1B.XP[3] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_3.MXPA1 NXBP1_3 _XP1B.XP[3] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_4.MXNA1 NXBP1_4 _XP1B.XP[4] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_4.MXPA1 NXBP1_4 _XP1B.XP[4] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_5.MXNA1 NXBP1_5 _XP1B.XP[5] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_5.MXPA1 NXBP1_5 _XP1B.XP[5] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_6.MXNA1 NXBP1_6 _XP1B.XP[6] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_6.MXPA1 NXBP1_6 _XP1B.XP[6] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
X_M_xp1b._iv_nxp_7.MXNA1 NXBP1_7 _XP1B.XP[7] VSS VPW N11LL_CKT W=2.38U L=0.04U
X_M_xp1b._iv_nxp_7.MXPA1 NXBP1_7 _XP1B.XP[7] VDDPE VNWP P11LL_CKT W=3.18U
+  L=0.04U
.ENDS RAMTP128X16WD32X2
****
.SUBCKT RAMTP128X16WD2X2 DBLA DBLA_DUM0 DBLA_DUM1 DBLB GA0 GA1 GB0 GB1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC NI0A NI0B NI1A
+  NI1B NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6
+  NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7
+  NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0
+  NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 R0A R0B R1A R1B
+  RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC_WLA0 VDDC_WLA1 VDDC_WLB0 VDDC_WLB1 VDDPE VDDP_WDA VDDP_WDB
+  VNWC VNWP VPW VSS VSSE WLA0 WLA1 WLB0 WLB1
** RAMTP128X16WD2X2: 43 flat devices **
X_MXNpg_wd_dp299_dbla_dum1 DBLA_DUM1 LOG0_DWLA VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_wd_base.I8.MX_npd _WD_BASE.ROWSELA RETA VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8.MX_nr_header VDDP_WDA RETA VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base.I8._nr.MXNA1 _WD_BASE.ROWSELA GA0 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8._nr.MXNA2 _WD_BASE.ROWSELA GA1 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I8._nr.MXPA1 _WD_BASE.ROWSELA GA0 _WD_BASE.I8._NR.P1 VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base.I8._nr.MXPA2 _WD_BASE.I8._NR.P1 GA1 VDDP_WDA VNWP P11LL_CKT
+  W=1.135U L=0.04U
X_M_wd_base.I9.MX_npd _WD_BASE.ROWSELB RETB VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9.MX_nr_header VDDP_WDB RETB VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_M_wd_base.I9._nr.MXNA1 _WD_BASE.ROWSELB GB0 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9._nr.MXNA2 _WD_BASE.ROWSELB GB1 VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_wd_base.I9._nr.MXPA1 _WD_BASE.ROWSELB GB0 _WD_BASE.I9._NR.P1 VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_M_wd_base.I9._nr.MXPA2 _WD_BASE.I9._NR.P1 GB1 VDDP_WDB VNWP P11LL_CKT
+  W=1.135U L=0.04U
X_M_wd_base._drvwla0.MXN10 NI0A R0A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwla0.MXN11 WLA0 _WD_BASE._DRVWLA0.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwla0.MXN8 _WD_BASE._DRVWLA0.NWL _WD_BASE.ROWSELA NI0A VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwla0.MXP12 _WD_BASE._DRVWLA0.NWL R0A VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwla0.MXP13 _WD_BASE._DRVWLA0.NWL _WD_BASE.ROWSELA VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwla0.MXP7 WLA0 _WD_BASE._DRVWLA0.NWL VDDC_WLA0 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwla1.MXN10 NI1A R1A VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwla1.MXN11 WLA1 _WD_BASE._DRVWLA1.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwla1.MXN8 _WD_BASE._DRVWLA1.NWL _WD_BASE.ROWSELA NI1A VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwla1.MXP12 _WD_BASE._DRVWLA1.NWL R1A VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwla1.MXP13 _WD_BASE._DRVWLA1.NWL _WD_BASE.ROWSELA VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwla1.MXP7 WLA1 _WD_BASE._DRVWLA1.NWL VDDC_WLA1 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwlb0.MXN10 NI0B R0B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwlb0.MXN11 WLB0 _WD_BASE._DRVWLB0.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwlb0.MXN8 _WD_BASE._DRVWLB0.NWL _WD_BASE.ROWSELB NI0B VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwlb0.MXP12 _WD_BASE._DRVWLB0.NWL R0B VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwlb0.MXP13 _WD_BASE._DRVWLB0.NWL _WD_BASE.ROWSELB VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwlb0.MXP7 WLB0 _WD_BASE._DRVWLB0.NWL VDDC_WLB0 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_base._drvwlb1.MXN10 NI1B R1B VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_wd_base._drvwlb1.MXN11 WLB1 _WD_BASE._DRVWLB1.NWL VSSE VPW N11LL_CKT
+  W=4.84U L=0.04U
X_M_wd_base._drvwlb1.MXN8 _WD_BASE._DRVWLB1.NWL _WD_BASE.ROWSELB NI1B VPW
+  N11LL_CKT W=1.99U L=0.04U
X_M_wd_base._drvwlb1.MXP12 _WD_BASE._DRVWLB1.NWL R1B VDDCE VNWC P11LL_CKT
+  W=1.18U L=0.04U
X_M_wd_base._drvwlb1.MXP13 _WD_BASE._DRVWLB1.NWL _WD_BASE.ROWSELB VDDCE VNWC
+  P11LL_CKT W=0.37U L=0.04U
X_M_wd_base._drvwlb1.MXP7 WLB1 _WD_BASE._DRVWLB1.NWL VDDC_WLB1 VNWC P11LL_CKT
+  W=7U L=0.04U
X_M_wd_dp299_dbla.MXNpg_0 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_wd_dp299_dbla.MXNpg_1 DBLA LOG0_DWLA VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_wd_dp299_dbla_dum0.MXNpg_0 DBLA_DUM0 LOG0_DWLA VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_wd_dp299_dbla_dum0.MXNpg_1 DBLA_DUM0 LOG0_DWLA VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_M_wd_dp299_dblb.MXNpg_0 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.45U L=0.04U
X_M_wd_dp299_dblb.MXNpg_1 DBLB LOG0_DWLB VSS VPW N11LL_CKT W=0.45U L=0.04U
.ENDS RAMTP128X16WD2X2
****
.SUBCKT RAMTP128X16WD2X2TOP DBLA DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A
+  N2B N3A N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5
+  NXAP0_6 NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6
+  NXAP1_7 NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7
+  NXBP1_0 NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RETA RETB
+  ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B
+  VDDC VDDCE VDDC_CCL VDDC_CCR VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECA2
+  VDDC_FDECA3 VDDC_FDECB0 VDDC_FDECB1 VDDC_FDECB2 VDDC_FDECB3 VDDC_WLA0
+  VDDC_WLA1 VDDC_WLB0 VDDC_WLB1 VDDPE VDDP_WDA VDDP_WDB VNWC VNWP VPW VSS
+  VSSE
** RAMTP128X16WD2X2TOP: 12 flat devices **
X_MI100.MXP2 VDDC_FDECB0 RETB VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_MI1_1.MXP0 N3B ROWCLK3B VDDC_FDECB1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI1_1.MXP2 N1B ROWCLK1B VDDC_FDECB1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP0 N2B ROWCLK2B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI2_1.MXP2 N0B ROWCLK0B VDDC_FDECB0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MI99.MXP2 VDDC_FDECB1 RETB VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_MRowDum_0.MXP0 N2A ROWCLK2A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_0.MXP2 N0A ROWCLK0A VDDC_FDECA0 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP0 N3A ROWCLK3A VDDC_FDECA1 VNWC P11LL_CKT W=1.67U L=0.04U
X_MRowDum_1.MXP2 N1A ROWCLK1A VDDC_FDECA1 VNWC P11LL_CKT W=1.67U L=0.04U
X_M_fdechdra0.MXP2 VDDC_FDECA0 RETA VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
X_M_fdechdra1.MXP2 VDDC_FDECA1 RETA VDDCE VNWC P11LL_CKT W=4.26U L=0.04U
.ENDS RAMTP128X16WD2X2TOP
****
.SUBCKT RAMTP128X16WD_STACK DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1]
+  LOG0_DWLA LOG0_DWLB LOG1A LOG1B NACTC NRETNVT RAA[0] RAA[1] RAA[2] RAA[3]
+  RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC
+  VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0 VDDC_FDECB1 VDDPE VPW WLA0_0 WLA0_1
+  WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11
+  WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4
+  WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14
+  WLA1_15 WLA1_16 WLA2 WLA3 WLA4 WLA5 WLA6 WLA7 WLA8 WLA9 WLA10 WLA11 WLA12
+  WLA13 WLA14 WLA15 WLA16 WLA17 WLA18 WLA19 WLA20 WLA21 WLA22 WLA23 WLA24
+  WLA25 WLA26 WLA27 WLA28 WLA29 WLA30 WLA31 WLB0_0 WLB0_1 WLB0_2 WLB0_3
+  WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13
+  WLB0_14 WLB0_15 WLB0_16 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6
+  WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15
+  WLB1_16 WLB2 WLB3 WLB4 WLB5 WLB6 WLB7 WLB8 WLB9 WLB10 WLB11 WLB12 WLB13
+  WLB14 WLB15 WLB16 WLB17 WLB18 WLB19 WLB20 WLB21 WLB22 WLB23 WLB24 WLB25
+  WLB26 WLB27 WLB28 WLB29 WLB30 WLB31
** RAMTP128X16WD_STACK: 1911 flat devices **
XBOTWDBLOCK DBLA_OUT DBLA_DUMO DBLA_OUT DBLA_UP DBLB DWLA DWLB EMAA[0] EMAA[1]
+  EMAA[2] EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1]
+  LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A LOG1B N0A N0B N1A N1B N2A N2B N3A
+  N3B NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6
+  NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7
+  NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0
+  NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RAA[0] RAA[1]
+  RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA
+  RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B VDDC VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_0 WLA1_0 WLA2 WLA3 WLA4 WLA5 WLA6 WLA7 WLA8 WLA9 WLA10 WLA11 WLA12
+  WLA13 WLA14 WLA15 WLA16 WLA17 WLA18 WLA19 WLA20 WLA21 WLA22 WLA23 WLA24
+  WLA25 WLA26 WLA27 WLA28 WLA29 WLA30 WLA31 WLB0_0 WLB1_0 WLB2 WLB3 WLB4 WLB5
+  WLB6 WLB7 WLB8 WLB9 WLB10 WLB11 WLB12 WLB13 WLB14 WLB15 WLB16 WLB17 WLB18
+  WLB19 WLB20 WLB21 WLB22 WLB23 WLB24 WLB25 WLB26 WLB27 WLB28 WLB29 WLB30
+  WLB31 RAMTP128X16WD32X2
XI16 DBLA_OUT DBLA_DUM0_98 DBLA_DUM1_100 DBLB NXAP0_0 NXAP1_1 NXBP0_0 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_1 WLA1_1 WLB0_1 WLB1_1 RAMTP128X16WD2X2
XI17 DBLA_OUT DBLA_DUM0_102 DBLA_DUM1_104 DBLB NXAP0_0 NXAP1_1 NXBP0_0 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_2 WLA1_2 WLB0_2 WLB1_2 RAMTP128X16WD2X2
XI18 DBLA_OUT DBLA_DUM0_106 DBLA_DUM1_108 DBLB NXAP0_1 NXAP1_1 NXBP0_1 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_3 WLA1_3 WLB0_3 WLB1_3 RAMTP128X16WD2X2
XI19 DBLA_OUT DBLA_DUM0_110 DBLA_DUM1_112 DBLB NXAP0_1 NXAP1_1 NXBP0_1 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_4 WLA1_4 WLB0_4 WLB1_4 RAMTP128X16WD2X2
XI20 DBLA_OUT DBLA_DUM0 DBLA_DUM1 DBLB NXAP0_2 NXAP1_1 NXBP0_2 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_5 WLA1_5 WLB0_5 WLB1_5 RAMTP128X16WD2X2
XI21 DBLA_OUT DBLA_DUM0_54 DBLA_DUM1_56 DBLB NXAP0_2 NXAP1_1 NXBP0_2 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_6 WLA1_6 WLB0_6 WLB1_6 RAMTP128X16WD2X2
XI22 DBLA_OUT DBLA_DUM0_58 DBLA_DUM1_60 DBLB NXAP0_3 NXAP1_1 NXBP0_3 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_7 WLA1_7 WLB0_7 WLB1_7 RAMTP128X16WD2X2
XI23 DBLA_OUT DBLA_DUM0_62 DBLA_DUM1_64 DBLB NXAP0_3 NXAP1_1 NXBP0_3 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_8 WLA1_8 WLB0_8 WLB1_8 RAMTP128X16WD2X2
XI24 DBLA_OUT DBLA_DUM0_66 DBLA_DUM1_68 DBLB NXAP0_4 NXAP1_1 NXBP0_4 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_9 WLA1_9 WLB0_9 WLB1_9 RAMTP128X16WD2X2
XI25 DBLA_OUT DBLA_DUM0_70 DBLA_DUM1_72 DBLB NXAP0_4 NXAP1_1 NXBP0_4 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_10 WLA1_10 WLB0_10 WLB1_10 RAMTP128X16WD2X2
XI26 DBLA_OUT DBLA_DUM0_74 DBLA_DUM1_76 DBLB NXAP0_5 NXAP1_1 NXBP0_5 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_11 WLA1_11 WLB0_11 WLB1_11 RAMTP128X16WD2X2
XI27 DBLA_OUT DBLA_DUM0_78 DBLA_DUM1_80 DBLB NXAP0_5 NXAP1_1 NXBP0_5 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_12 WLA1_12 WLB0_12 WLB1_12 RAMTP128X16WD2X2
XI28 DBLA_OUT DBLA_DUM0_82 DBLA_DUM1_84 DBLB NXAP0_6 NXAP1_1 NXBP0_6 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_13 WLA1_13 WLB0_13 WLB1_13 RAMTP128X16WD2X2
XI29 DBLA_OUT DBLA_DUM0_86 DBLA_DUM1_88 DBLB NXAP0_6 NXAP1_1 NXBP0_6 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_14 WLA1_14 WLB0_14 WLB1_14 RAMTP128X16WD2X2
XI30 DBLA_OUT DBLA_DUM0_90 DBLA_DUM1_92 DBLB NXAP0_7 NXAP1_1 NXBP0_7 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N0A N0B N1A N1B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK0A ROWCLK0B ROWCLK1A
+  ROWCLK1B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_15 WLA1_15 WLB0_15 WLB1_15 RAMTP128X16WD2X2
XTOPWD DBLA_OUT DBLA_DUM0_94 DBLA_DUM1_96 DBLB NXAP0_7 NXAP1_1 NXBP0_7 NXBP1_1
+  LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B NACTC N2A N2B N3A N3B
+  NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6 NXAP0_7
+  NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7 NXBP0_0
+  NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0 NXBP1_1
+  NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 ROWCLK2A ROWCLK2B ROWCLK3A
+  ROWCLK3B RETA RETB ROWCLK0A ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B
+  ROWCLK3A ROWCLK3B VDDC VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA VDDP_WDB VDDC VDDPE VPW VPW
+  VPW WLA0_16 WLA1_16 WLB0_16 WLB1_16 RAMTP128X16WD2X2
XTOPWDEND DBLA_OUT DBLB LOG0_DWLA LOG0_DWLB N0A N0B N1A N1B N2A N2B N3A N3B
+  NACTC NRETNVT NXAP0_0 NXAP0_1 NXAP0_2 NXAP0_3 NXAP0_4 NXAP0_5 NXAP0_6
+  NXAP0_7 NXAP1_0 NXAP1_1 NXAP1_2 NXAP1_3 NXAP1_4 NXAP1_5 NXAP1_6 NXAP1_7
+  NXBP0_0 NXBP0_1 NXBP0_2 NXBP0_3 NXBP0_4 NXBP0_5 NXBP0_6 NXBP0_7 NXBP1_0
+  NXBP1_1 NXBP1_2 NXBP1_3 NXBP1_4 NXBP1_5 NXBP1_6 NXBP1_7 RETA RETB ROWCLK0A
+  ROWCLK0B ROWCLK1A ROWCLK1B ROWCLK2A ROWCLK2B ROWCLK3A ROWCLK3B VDDC VDDC
+  VDDC VDDC VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECA0 VDDC_FDECA1 VDDC_FDECB0
+  VDDC_FDECB1 VDDC_FDECB0 VDDC_FDECB1 VDDC VDDC VDDC VDDC VDDPE VDDP_WDA
+  VDDP_WDB VDDC VDDPE VPW VPW VPW RAMTP128X16WD2X2TOP
.ENDS RAMTP128X16WD_STACK
****
.SUBCKT RAMTP128X16WD_STACKCAP DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1]
+  LOG0_DWLA LOG0_DWLB LOG1A LOG1B RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5]
+  RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC VDDPE VSSE WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19
+  WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28
+  WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6
+  WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15
+  WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24
+  WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1
+  WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11
+  WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20
+  WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29
+  WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7
+  WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16
+  WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25
+  WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16WD_STACKCAP: 1911 flat devices **
XWD_STACK DBLA_OUT DBLB DWLA DWLB EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1]
+  EMAB[2] GTPA0 GTPA1 GTPB0 GTPB1 LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA
+  LOG0_DWLB LOG1A LOG1B VSSE VSSE RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5]
+  RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RETA RETB VDDC VDDC_FDECA1
+  VDDC_FDECA1 VDDC_FDECB1 VDDC_FDECB1 VDDPE VSSE WLA0_0 WLA0_16 WLA0_17
+  WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26
+  WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLA0_1 WLA1_1 WLA0_2 WLA1_2 WLA0_3 WLA1_3
+  WLA0_4 WLA1_4 WLA0_5 WLA1_5 WLA0_6 WLA1_6 WLA0_7 WLA1_7 WLA0_8 WLA1_8
+  WLA0_9 WLA1_9 WLA0_10 WLA1_10 WLA0_11 WLA1_11 WLA0_12 WLA1_12 WLA0_13
+  WLA1_13 WLA0_14 WLA1_14 WLA0_15 WLA1_15 WLB0_0 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_16 WLB1_17 WLB1_18 WLB1_19
+  WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28
+  WLB1_29 WLB1_30 WLB1_31 WLB0_1 WLB1_1 WLB0_2 WLB1_2 WLB0_3 WLB1_3 WLB0_4
+  WLB1_4 WLB0_5 WLB1_5 WLB0_6 WLB1_6 WLB0_7 WLB1_7 WLB0_8 WLB1_8 WLB0_9
+  WLB1_9 WLB0_10 WLB1_10 WLB0_11 WLB1_11 WLB0_12 WLB1_12 WLB0_13 WLB1_13
+  WLB0_14 WLB1_14 WLB0_15 WLB1_15 RAMTP128X16WD_STACK
.ENDS RAMTP128X16WD_STACKCAP
****
.SUBCKT RAMTP128X16WRM2_BSTWM D DFTB RD SEL_D SEL_SI SEL_TD SI SO TD TE TWEN
+  TWENL TWENR VDDCE VDDPE VNWP VPW VSS VSSE WCLK WEN WENL WENR WENY WRONE
+  WRZERO
** RAMTP128X16WRM2_BSTWM: 92 flat devices **
X_MI1.MXNA1 DWE_LAT NET72 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI1.MXNA2 DWE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI1.MXPA1 DWE_LAT NET72 I1.P1 VNWP P11LL_CKT W=0.445U L=0.04U
X_MI1.MXPA2 I1.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MI160.MXNA1 IWCLK NWCLK VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MI160.MXPA1 IWCLK NWCLK VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MI165.MXNA1 NWCLK WCLK VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI165.MXPA1 NWCLK WCLK VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_MI168.MXNA1 NET110 DWE_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI168.MXPA1 NET110 DWE_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI169.MXNA1 NET122 NDWE_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI169.MXPA1 NET122 NDWE_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI170.MXNA1 WE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI170.MXPA1 WE_LAT WEN_LAT VDDPE VNWP P11LL_CKT W=0.325U L=0.04U
X_MI171.MXNA1 NET72 D_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI171.MXPA1 NET72 D_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MI2.MXNA1 NDWE_LAT D_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI2.MXNA2 NDWE_LAT WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI2.MXPA1 NDWE_LAT D_LAT I2.P1 VNWP P11LL_CKT W=0.445U L=0.04U
X_MI2.MXPA2 I2.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MXN0 WRONE NDWE_LAT VSS VPW N11LL_CKT W=1.6U L=0.04U
X_MXN2 WRZERO DWE_LAT VSS VPW N11LL_CKT W=1.6U L=0.04U
X_MXP0 WRONE NET110 VDDPE VNWP P11LL_CKT W=0.65U L=0.04U
X_MXP2 WRZERO NET122 VDDPE VNWP P11LL_CKT W=0.65U L=0.04U
X_MXP3 NET104 IWCLK VDDPE VNWP P11LL_CKT W=0.535U L=0.04U
X_MXP5 WRONE WE_LAT NET104 VNWP P11LL_CKT W=0.535U L=0.04U
X_MXP6 NET96 IWCLK VDDPE VNWP P11LL_CKT W=0.535U L=0.04U
X_MXP7 WRZERO WE_LAT NET96 VNWP P11LL_CKT W=0.535U L=0.04U
X_M_dft_lat.I0.MXNA1 _DFT_LAT.I0.N1 D_LAT VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dft_lat.I0.MXNOE _DFT_LAT.ND D_LAT _DFT_LAT.I0.N1 VPW N11LL_CKT W=0.16U
+  L=0.04U
X_M_dft_lat.I0.MXPA1 _DFT_LAT.I0.P1 D_LAT VDDPE VNWP P11LL_CKT W=0.16U L=0.04U
X_M_dft_lat.I0.MXPOEN _DFT_LAT.ND D_LAT _DFT_LAT.I0.P1 VNWP P11LL_CKT W=0.16U
+  L=0.04U
X_M_dft_lat.I1.MXNOE DFT_LAT_NQ IWCLK _DFT_LAT.ND VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_dft_lat.I1.MXPOEN DFT_LAT_NQ NWCLK _DFT_LAT.ND VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_dft_lat.I2.MXNA1 SO DFT_LAT_NQ VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dft_lat.I2.MXPA1 SO DFT_LAT_NQ VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_M_dft_lat.I3.MXNA1 _DFT_LAT.I3.N1 SO VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_dft_lat.I3.MXNOE DFT_LAT_NQ NWCLK _DFT_LAT.I3.N1 VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_dft_lat.I3.MXPA1 _DFT_LAT.I3.P1 SO VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_M_dft_lat.I3.MXPOEN DFT_LAT_NQ IWCLK _DFT_LAT.I3.P1 VNWP P11LL_CKT W=0.14U
+  L=0.04U
X_M_dlat.I1_0.MXNA1 _DLAT.NSEL3 SEL_SI VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I1_0.MXPA1 _DLAT.NSEL3 SEL_SI VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.I1_1.MXNA1 _DLAT.NSEL2 SEL_TD VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I1_1.MXPA1 _DLAT.NSEL2 SEL_TD VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.I1_2.MXNA1 _DLAT.NSEL1 SEL_D VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I1_2.MXPA1 _DLAT.NSEL1 SEL_D VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.I50.MXNA1 D_LAT DLAT_NQ VSS VPW N11LL_CKT W=0.215U L=0.04U
X_M_dlat.I50.MXPA1 D_LAT DLAT_NQ VDDPE VNWP P11LL_CKT W=0.325U L=0.04U
X_M_dlat.I55.MXNA1 _DLAT.I55.N1 D_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXNOE DLAT_NQ IWCLK _DLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXPA1 _DLAT.I55.P1 D_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_dlat.I55.MXPOEN DLAT_NQ NWCLK _DLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_dlat.I65.MXNOE DLAT_NQ NWCLK _DLAT.ND VPW N11LL_CKT W=0.215U L=0.04U
X_M_dlat.I65.MXPOEN DLAT_NQ IWCLK _DLAT.ND VNWP P11LL_CKT W=0.215U L=0.04U
X_M_dlat.MXN1 _DLAT.N2 TD VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXN2 _DLAT.N1 D VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXN3 _DLAT.ND SEL_D _DLAT.N1 VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXN4 _DLAT.ND SEL_TD _DLAT.N2 VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXN5 _DLAT.N3 SI VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXN6 _DLAT.ND SEL_SI _DLAT.N3 VPW N11LL_CKT W=0.16U L=0.04U
X_M_dlat.MXP0 _DLAT.ND _DLAT.NSEL1 _DLAT.P1 VNWP P11LL_CKT W=0.245U L=0.04U
X_M_dlat.MXP1 _DLAT.P1 D VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_M_dlat.MXP2 _DLAT.ND _DLAT.NSEL2 _DLAT.P2 VNWP P11LL_CKT W=0.245U L=0.04U
X_M_dlat.MXP3 _DLAT.P2 TD VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_M_dlat.MXP4 _DLAT.ND _DLAT.NSEL3 _DLAT.P3 VNWP P11LL_CKT W=0.245U L=0.04U
X_M_dlat.MXP5 _DLAT.P3 SI VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_M_wenlat.I0.MXNA1 _WENLAT.NDY _WENLAT.IDY _WENLAT.I0.N1 VPW N11LL_CKT
+  W=0.17U L=0.04U
X_M_wenlat.I0.MXNA2 _WENLAT.I0.N1 DFTB VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_wenlat.I0.MXPA1 _WENLAT.NDY _WENLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_wenlat.I0.MXPA2 _WENLAT.NDY DFTB VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_wenlat.I50.MXNA1 WEN_LAT WENLAT_NQ VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_wenlat.I50.MXPA1 WEN_LAT WENLAT_NQ VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
X_M_wenlat.I55.MXNA1 _WENLAT.I55.N1 WEN_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I55.MXNOE WENLAT_NQ IWCLK _WENLAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I55.MXPA1 _WENLAT.I55.P1 WEN_LAT VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I55.MXPOEN WENLAT_NQ NWCLK _WENLAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I57.MXNA1 _WENLAT.NSEL TE VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_wenlat.I57.MXPA1 _WENLAT.NSEL TE VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_M_wenlat.I62.MXNA1 WENY _WENLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_M_wenlat.I62.MXPA1 WENY _WENLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_M_wenlat.I63.MXNA1 _WENLAT.IDY _WENLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I63.MXPA1 _WENLAT.IDY _WENLAT.ND VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.I65.MXNOE WENLAT_NQ NWCLK _WENLAT.ND VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.I65.MXPOEN WENLAT_NQ IWCLK _WENLAT.ND VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_wenlat.MXN1 _WENLAT.ND TWEN _WENLAT.N2 VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.MXN2 _WENLAT.ND WEN _WENLAT.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.MXN5 _WENLAT.N1 _WENLAT.NSEL VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.MXN6 _WENLAT.N2 TE VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_wenlat.MXP1 _WENLAT.ND WEN _WENLAT.P1 VNWP P11LL_CKT W=0.16U L=0.04U
X_M_wenlat.MXP3 _WENLAT.ND TWEN _WENLAT.P2 VNWP P11LL_CKT W=0.16U L=0.04U
X_M_wenlat.MXP4 _WENLAT.P1 TE VDDPE VNWP P11LL_CKT W=0.16U L=0.04U
X_M_wenlat.MXP5 _WENLAT.P2 _WENLAT.NSEL VDDPE VNWP P11LL_CKT W=0.16U L=0.04U
.ENDS RAMTP128X16WRM2_BSTWM
****
.SUBCKT RAMTP128X16WR_COLX_L DFTB D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1
+  RD_2 RD_3 RD_4 RD_5 RD_6 RD_7 SEL_D SEL_SI SEL_TD SI SO TD_0 TD_1 TD_2 TD_3
+  TD_4 TD_5 TD_6 TD_7 TE TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDPE VNWP VPW WCLK WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6
+  WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WRONE_0 WRONE_1 WRONE_2
+  WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7 WRZERO_0 WRZERO_1 WRZERO_2 WRZERO_3
+  WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7
** RAMTP128X16WR_COLX_L: 736 flat devices **
XWR_1 D_1 DFTB RD_1 SEL_D SEL_SI SEL_TD SO_0 SO_4 TD_1 TE TWEN_1 TWEN_1 TWEN_2
+  VDDCE_1 VDDPE VNWP VPW VPW VPW WCLK WEN_1 WEN_1 WEN_2 WENY_1 WRONE_1
+  WRZERO_1 RAMTP128X16WRM2_BSTWM
XWR_2 D_2 DFTB RD_2 SEL_D SEL_SI SEL_TD SO_4 SO_6 TD_2 TE TWEN_2 TWEN_2 TWEN_3
+  VDDCE_2 VDDPE VNWP VPW VPW VPW WCLK WEN_2 WEN_2 WEN_3 WENY_2 WRONE_2
+  WRZERO_2 RAMTP128X16WRM2_BSTWM
XWR_3 D_3 DFTB RD_3 SEL_D SEL_SI SEL_TD SO_6 SO_8 TD_3 TE TWEN_3 TWEN_3 TWEN_4
+  VDDCE_3 VDDPE VNWP VPW VPW VPW WCLK WEN_3 WEN_3 WEN_4 WENY_3 WRONE_3
+  WRZERO_3 RAMTP128X16WRM2_BSTWM
XWR_4 D_4 DFTB RD_4 SEL_D SEL_SI SEL_TD SO_8 SO_10 TD_4 TE TWEN_4 TWEN_4
+  TWEN_5 VDDCE_4 VDDPE VNWP VPW VPW VPW WCLK WEN_4 WEN_4 WEN_5 WENY_4 WRONE_4
+  WRZERO_4 RAMTP128X16WRM2_BSTWM
XWR_5 D_5 DFTB RD_5 SEL_D SEL_SI SEL_TD SO_10 SO_12 TD_5 TE TWEN_5 TWEN_5
+  TWEN_6 VDDCE_5 VDDPE VNWP VPW VPW VPW WCLK WEN_5 WEN_5 WEN_6 WENY_5 WRONE_5
+  WRZERO_5 RAMTP128X16WRM2_BSTWM
XWR_6 D_6 DFTB RD_6 SEL_D SEL_SI SEL_TD SO_12 SI_2 TD_6 TE TWEN_6 TWEN_6 TWENR
+  VDDCE_6 VDDPE VNWP VPW VPW VPW WCLK WEN_6 WEN_6 WENR WENY_6 WRONE_6
+  WRZERO_6 RAMTP128X16WRM2_BSTWM
XWR_FARWD D_7 DFTB RD_7 SEL_D SEL_SI SEL_TD SI_2 SO TD_7 TE TWENR TWENR TWENR
+  VDDCE_7 VDDPE VNWP VPW VPW VPW WCLK WENR WENR WENR WENY_7 WRONE_7 WRZERO_7
+  RAMTP128X16WRM2_BSTWM
XWR_NEARWD D_0 DFTB RD_0 SEL_D SEL_SI SEL_TD SI SO_0 TD_0 TE TWEN_0 TWEN_0
+  TWEN_1 VDDCE_0 VDDPE VNWP VPW VPW VPW WCLK WEN_0 WEN_0 WEN_1 WENY_0 WRONE_0
+  WRZERO_0 RAMTP128X16WRM2_BSTWM
.ENDS RAMTP128X16WR_COLX_L
****
.SUBCKT RAMTP128X16RDM2 D Q RD0 TD TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN WENY
** RAMTP128X16RDM2: 2 flat devices **
X_MIV_Q.MXNA1 Q RD0 VSS VPW N11LL_CKT W=2.01U L=0.04U
X_MIV_Q.MXPA1 Q RD0 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
.ENDS RAMTP128X16RDM2
****
.SUBCKT RAMTP128X16RD_COLX_L D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 RD0_0 RD0_1 RD0_2 RD0_3 RD0_4 RD0_5 RD0_6 RD0_7 TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1 VPW_2
+  VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSSE_0 VSSE_1 VSSE_2 VSSE_3 VSSE_4 VSSE_5
+  VSSE_6 VSSE_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7
** RAMTP128X16RD_COLX_L: 16 flat devices **
XRD_1 D_1 Q_1 RD0_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1 VNWP_1 VPW_1 VSS_1 VSSE_1
+  WEN_1 WENY_1 RAMTP128X16RDM2
XRD_2 D_2 Q_2 RD0_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2 VNWP_2 VPW_2 VSS_2 VSSE_2
+  WEN_2 WENY_2 RAMTP128X16RDM2
XRD_3 D_3 Q_3 RD0_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3 VSS_3 VSSE_3
+  WEN_3 WENY_3 RAMTP128X16RDM2
XRD_4 D_4 Q_4 RD0_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4 VNWP_4 VPW_4 VSS_4 VSSE_4
+  WEN_4 WENY_4 RAMTP128X16RDM2
XRD_5 D_5 Q_5 RD0_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5 VNWP_5 VPW_5 VSS_5 VSSE_5
+  WEN_5 WENY_5 RAMTP128X16RDM2
XRD_6 D_6 Q_6 RD0_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6 VNWP_6 VPW_6 VSS_6 VSSE_6
+  WEN_6 WENY_6 RAMTP128X16RDM2
XRD_FARWD D_7 Q_7 RD0_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7 VNWP_7 VPW_7 VSS_7 VSSE_7
+  WEN_7 WENY_7 RAMTP128X16RDM2
XRD_NEARWD D_0 Q_0 RD0_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0 VSS_0 VSSE_0
+  WEN_0 WENY_0 RAMTP128X16RDM2
.ENDS RAMTP128X16RD_COLX_L
****
.SUBCKT RAMTP128X16CDM2EDGE_BST DFT DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYPCOL0 NYPCOL1 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SIA SIB SOA SOB TIELO VDDCE VDDPE VNWC VNWP VPW VSS VSSE
** RAMTP128X16CDM2EDGE_BST: 10 flat devices **
X_MI0.MXNA1 NET69 NET45 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI0.MXPA1 NET69 NET45 VDDPE VNWC P11LL_CKT W=0.245U L=0.04U
X_MI1.MXNA1 NET45 SIA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI1.MXPA1 NET45 SIA VDDPE VNWC P11LL_CKT W=0.15U L=0.04U
X_MI17.MXNA1 SOA NET69 VSS VPW N11LL_CKT W=0.54U L=0.04U
X_MI17.MXPA1 SOA NET69 VDDPE VNWC P11LL_CKT W=1.08U L=0.04U
X_MI2.MXNA1 SOB NET57 VSS VPW N11LL_CKT W=0.54U L=0.04U
X_MI2.MXPA1 SOB NET57 VDDPE VNWP P11LL_CKT W=1.08U L=0.04U
X_MI3.MXNA1 NET57 SIB VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI3.MXPA1 NET57 SIB VDDPE VNWP P11LL_CKT W=0.245U L=0.04U
.ENDS RAMTP128X16CDM2EDGE_BST
****
.SUBCKT RAMTP128X16ENDBOT_COL_LT DFT_0 DFT_1 DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYPCOL0 NYPCOL1 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SEL_D SEL_SI SEL_TD SIA SIB TE TIELO_0 TIELO_1 TWEN VDDCE
+  VDDPE VNWC VNWP VPW_0 VPW_1 VSSE VSS_0 VSS_1 WCLK WEN
** RAMTP128X16ENDBOT_COL_LT: 10 flat devices **
XCDEDGECELL DFT_1 DWL DWLTURN NSAE_TERM NYP0A_TERM NYP0B_TERM NYP1A_TERM
+  NYP1B_TERM NYPCOL0 NYPCOL1 PRECHA_TERM PRECHB_TERM SAPRECH_TERM SIA SIB SOA
+  SOB TIELO_1 VDDCE VDDPE VNWC VDDPE VPW_0 VSS_1 VSSE RAMTP128X16CDM2EDGE_BST
.ENDS RAMTP128X16ENDBOT_COL_LT
****
.SUBCKT RAMTP128X16CDM2_BST BLA0 BLA1 BLB0 BLB1 DFT DWL DWLTURN NBLA0 NBLA1
+  NBLB0 NBLB1 NSAE NWRDATA NYPCLK0A NYPCLK1A PRECHA PRECHB RD SAPRECH SI SO
+  TIELO VDDC VDDCE VDDPE VNWC VNWP VPW VSS VSSE WRDATA YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1
** RAMTP128X16CDM2_BST: 83 flat devices **
X_M_cd_01.I62.MXNA1 _CD_01.NPRECHA PRECHA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_01.I62.MXPA1 _CD_01.NPRECHA PRECHA VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_01.I80.MXNA1 _CD_01.NPRECHB PRECHB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_cd_01.I80.MXPA1 _CD_01.NPRECHB PRECHB VDDPE VNWC P11LL_CKT W=0.35U L=0.04U
X_M_cd_01._cmuxa0.MXP0 NSD NYPCLK0A BLA0 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa0.MXP91 NBLA0 NYPCLK0A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa0.MXPEQ BLA0 _CD_01.NPRECHA NBLA0 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa0.MXPPU0 NBLA0 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa0.MXPPU1 BLA0 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXP0 NSD NYPCLK1A BLA1 VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa1.MXP91 NBLA1 NYPCLK1A SD VNWC P11LL_CKT W=0.42U L=0.04U
X_M_cd_01._cmuxa1.MXPEQ BLA1 _CD_01.NPRECHA NBLA1 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXPPU0 NBLA1 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxa1.MXPPU1 BLA1 _CD_01.NPRECHA VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.IV_Mux.MXNA1 _CD_01._CMUXB0.NYP YPCLK0B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_01._cmuxb0.IV_Mux.MXPA1 _CD_01._CMUXB0.NYP YPCLK0B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_01._cmuxb0.MXPEQ BLB0 _CD_01.NPRECHB NBLB0 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.MXPPU0 NBLB0 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.MXPPU1 BLB0 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb0.TG0.MXNOE NBLB0 YPCLK0B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_01._cmuxb0.TG0.MXPOEN NBLB0 _CD_01._CMUXB0.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb0.TG1.MXNOE BLB0 YPCLK0B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_01._cmuxb0.TG1.MXPOEN BLB0 _CD_01._CMUXB0.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb1.IV_Mux.MXNA1 _CD_01._CMUXB1.NYP YPCLK1B VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_cd_01._cmuxb1.IV_Mux.MXPA1 _CD_01._CMUXB1.NYP YPCLK1B VDDPE VNWC P11LL_CKT
+  W=0.2U L=0.04U
X_M_cd_01._cmuxb1.MXPEQ BLB1 _CD_01.NPRECHB NBLB1 VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.MXPPU0 NBLB1 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.MXPPU1 BLB1 _CD_01.NPRECHB VDDPE VNWC P11LL_CKT W=0.4U
+  L=0.04U
X_M_cd_01._cmuxb1.TG0.MXNOE NBLB1 YPCLK1B NWRDATA VPW N11LL_CKT W=0.98U
+  L=0.04U
X_M_cd_01._cmuxb1.TG0.MXPOEN NBLB1 _CD_01._CMUXB1.NYP NWRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._cmuxb1.TG1.MXNOE BLB1 YPCLK1B WRDATA VPW N11LL_CKT W=0.98U L=0.04U
X_M_cd_01._cmuxb1.TG1.MXPOEN BLB1 _CD_01._CMUXB1.NYP WRDATA VNWC P11LL_CKT
+  W=0.48U L=0.04U
X_M_cd_01._collcmux0.MXN0 BLA0 YPCOLCLK0 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux0.MXN3 NBLA0 YPCOLCLK0 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux1.MXN0 BLA1 YPCOLCLK1 WRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_cd_01._collcmux1.MXN3 NBLA1 YPCOLCLK1 NWRDATA VPW N11LL_CKT W=0.8U L=0.04U
X_M_dwl_load_0.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_0.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_0.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl2 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_dwl_load_1.MXNpgl3 VSS DWL VSS VPW N11LL_CKT W=0.16U L=0.04U
X_M_sa.I1.MXNA1 _SA.NDFT _SA.NSAPRECH _SA.I1.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXNA2 _SA.I1.N1 DFT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXPA1 _SA.NDFT _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_sa.I1.MXPA2 _SA.NDFT DFT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_sa.I46.MXNA1 BSAE NSAE VSS VPW N11LL_CKT W=0.19U L=0.04U
X_M_sa.I46.MXPA1 BSAE NSAE VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_sa.I60.MXNA1 _SA.NSI SI VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_sa.I60.MXPA1 _SA.NSI SI VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_M_sa.MXN0 VSS TIELO VSS VPW N11LL_CKT W=0.96U L=0.08U
X_M_sa.MXP11 _SA.ISI BSAE SI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP12 SD _SA.NDFT _SA.ISI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP13 NSD _SA.NDFT _SA.NISI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa.MXP14 _SA.NISI BSAE _SA.NSI VNWP P11LL_CKT W=0.27U L=0.04U
X_M_sa._mem_senseamp.MXN17 NSD SD _SA.NET051 VPW N11LL_CKT W=2.4U L=0.08U
X_M_sa._mem_senseamp.MXN18 _SA.NET051 BSAE VSS VPW N11LL_CKT W=1.2U L=0.04U
X_M_sa._mem_senseamp.MXN19 SD NSD _SA.NET051 VPW N11LL_CKT W=2.4U L=0.08U
X_M_sa._mem_senseamp.MXP24 NSD _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_sa._mem_senseamp.MXP25 NSD _SA.NSAPRECH SD VNWP P11LL_CKT W=0.4U L=0.04U
X_M_sa._mem_senseamp.MXP26 SD _SA.NSAPRECH VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_M_sa._mem_senseamp.MXP27 NSD SD VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_sa._mem_senseamp.MXP28 SD NSD VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_sa._ndnsapre.MXN0 _SA._NDNSAPRE.NET15 NLAT_E VSS VPW N11LL_CKT W=0.48U
+  L=0.04U
X_M_sa._ndnsapre.MXN1 _SA.NSAPRECH SAPRECH _SA._NDNSAPRE.NET15 VPW N11LL_CKT
+  W=0.24U L=0.04U
X_M_sa._ndnsapre.MXP0 _SA.NSAPRECH NLAT_E VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_M_sa._ndnsapre.MXP12 _SA.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_salat.I62.MXNA1 RD _SALAT.SD_LAT VSS VPW N11LL_CKT W=0.485U L=0.04U
X_M_salat.I62.MXPA1 RD _SALAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.61U L=0.04U
X_M_salat.I63.MXNA1 _SALAT.IRD _SALAT.SD_LAT VSS VPW N11LL_CKT W=0.12U L=0.04U
X_M_salat.I63.MXPA1 _SALAT.IRD _SALAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.12U
+  L=0.04U
X_M_salat.I82.MXNA1 NLAT_E BSAE VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_salat.I82.MXPA1 NLAT_E BSAE VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_salat.MXN8 _SALAT.N1B _SALAT.IRD VSS VPW N11LL_CKT W=0.135U L=0.04U
X_M_salat.MXN9 _SALAT.SD_LAT NLAT_E _SALAT.N1B VPW N11LL_CKT W=0.135U L=0.04U
X_M_salat.MXP6 _SALAT.SD_LAT BSAE _SALAT.P1B VNWP P11LL_CKT W=0.16U L=0.04U
X_M_salat.MXP7 _SALAT.P1B _SALAT.IRD VDDPE VNWP P11LL_CKT W=0.16U L=0.04U
X_M_salat.MXPs _SALAT.SD_LAT SD _SALAT.P1A VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_ndmy _SALAT.NSD_DUM NSD _SALAT.N1A VPW N11LL_CKT W=0.27U L=0.04U
X_M_salat.MX_nlat _SALAT.N1A BSAE VSS VPW N11LL_CKT W=0.27U L=0.04U
X_M_salat.MX_pdmy _SALAT.NSD_DUM NSD _SALAT.P1A VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_pnsae _SALAT.P1A NLAT_E VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_salat.MX_sd_n _SALAT.SD_LAT SD _SALAT.N1A VPW N11LL_CKT W=0.27U L=0.04U
.ENDS RAMTP128X16CDM2_BST
****
.SUBCKT RAMTP128X16CD_COLXREG_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1
+  BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2
+  NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3
+  NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4
+  NWRDATA_5 NWRDATA_6 NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1
+  RD_2 RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4
+  VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3
+  WRDATA_4 WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16CD_COLXREG_LT: 664 flat devices **
XCD_1 BLA0_1 BLA1_1 BLB0_1 BLB1_1 DFT DWL DWL NBLA0_1 NBLA1_1 NBLB0_1 NBLB1_1
+  NSAE NWRDATA_1 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_1 SAPRECH RD_0 RD_1 TIELO
+  VDDC_1 VDDCE_1 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_1 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 DFT DWL DWL NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  NSAE NWRDATA_2 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_2 SAPRECH RD_1 RD_2 TIELO
+  VDDC_2 VDDCE_2 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_2 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 DFT DWL DWL NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  NSAE NWRDATA_3 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_3 SAPRECH RD_2 RD_3 TIELO
+  VDDC_3 VDDCE_3 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_3 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 DFT DWL DWL NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  NSAE NWRDATA_4 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_4 SAPRECH RD_3 RD_4 TIELO
+  VDDC_4 VDDCE_4 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_4 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 DFT DWL DWL NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  NSAE NWRDATA_5 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_5 SAPRECH RD_4 RD_5 TIELO
+  VDDC_5 VDDCE_5 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_5 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 DFT DWL DWL NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  NSAE NWRDATA_6 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_6 SAPRECH RD_5 RD_6 TIELO
+  VDDC_6 VDDCE_6 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_6 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_FARWD BLA0_7 BLA1_7 BLB0_7 BLB1_7 DFT DWL DWL NBLA0_7 NBLA1_7 NBLB0_7
+  NBLB1_7 NSAE NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB SO SAPRECH RD_6 SO
+  TIELO VDDC_7 VDDCE_7 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_7 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 DFT DWL DWL NBLA0_0 NBLA1_0 NBLB0_0
+  NBLB1_0 NSAE NWRDATA_0 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 SAPRECH SI RD_0
+  TIELO VDDC_0 VDDCE_0 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_0 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
.ENDS RAMTP128X16CD_COLXREG_LT
****
.SUBCKT RAMTP128X16CD_COLX_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5
+  NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6
+  NBLB1_7 NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5
+  NWRDATA_6 NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3
+  RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16CD_COLX_LT: 664 flat devices **
XCD_COLXREG_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5
+  RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7
+  VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
+  RAMTP128X16CD_COLXREG_LT
.ENDS RAMTP128X16CD_COLX_LT
****
.SUBCKT RAMTP128X16FLBIOM2 D Q TD TIELO TWEN VDDCE VDDPE VNWP VPW VSS VSSE WEN
+  WENY
** RAMTP128X16FLBIOM2: 4 flat devices **
D0_0.D_Diode_X_dio VPW TWEN NDIO11LL AREA=0.035P PJ=0.78U
D0_1.D_Diode_X_dio VPW WEN NDIO11LL AREA=0.035P PJ=0.78U
D0_2.D_Diode_X_dio VPW TD NDIO11LL AREA=0.035P PJ=0.78U
D0_3.D_Diode_X_dio VPW D NDIO11LL AREA=0.035P PJ=0.78U
.ENDS RAMTP128X16FLBIOM2
****
.SUBCKT RAMTP128X16WRGLTNHD D Q TIELO VDDCE VDDPE VNWP VPW VSS WEN WENY
** RAMTP128X16WRGLTNHD: 4 flat devices **
XI0 D Q TIELO TIELO TIELO VDDCE VDDPE VNWP VPW VSS VSS WEN WENY
+  RAMTP128X16FLBIOM2
.ENDS RAMTP128X16WRGLTNHD
****
.SUBCKT RAMTP128X16XR_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VNWP VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3
+  WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP128X16XR_COLX_LT: 32 flat devices **
XI0 D_0 Q_0 TIELO VDDCE_0 VDDPE_0 VNWP VPW VSS_0 WEN_0 WENY_0
+  RAMTP128X16WRGLTNHD
XI1 D_1 Q_1 TIELO VDDCE_1 VDDPE_1 VNWP VPW VSS_1 WEN_1 WENY_1
+  RAMTP128X16WRGLTNHD
XI2 D_2 Q_2 TIELO VDDCE_2 VDDPE_2 VNWP VPW VSS_2 WEN_2 WENY_2
+  RAMTP128X16WRGLTNHD
XI3 D_3 Q_3 TIELO VDDCE_3 VDDPE_3 VNWP VPW VSS_3 WEN_3 WENY_3
+  RAMTP128X16WRGLTNHD
XI4 D_4 Q_4 TIELO VDDCE_4 VDDPE_4 VNWP VPW VSS_4 WEN_4 WENY_4
+  RAMTP128X16WRGLTNHD
XI5 D_5 Q_5 TIELO VDDCE_5 VDDPE_5 VNWP VPW VSS_5 WEN_5 WENY_5
+  RAMTP128X16WRGLTNHD
XI6 D_6 Q_6 TIELO VDDCE_6 VDDPE_6 VNWP VPW VSS_6 WEN_6 WENY_6
+  RAMTP128X16WRGLTNHD
XI7 D_7 Q_7 TIELO VDDCE_7 VDDPE_7 VNWP VPW VSS_7 WEN_7 WENY_7
+  RAMTP128X16WRGLTNHD
.ENDS RAMTP128X16XR_COLX_LT
****
.SUBCKT RAMTP128X16BOT_IO_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DFTB DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6
+  D_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0
+  NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1
+  NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2
+  NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NSAE NYPCLK0A NYPCLK1A PRECHA
+  PRECHB Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SI_0
+  SI_1 TE TIELO_0 TIELO_1 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDCE_8 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDPE VNWC VPW VSSE WCLK WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6
+  WEN_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16BOT_IO_LT: 1458 flat devices **
XCD_COLX_LT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NSAE WRZERO_0 WRZERO_1 WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6
+  WRZERO_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6
+  SAPRECH SI_1 RD_7 TIELO_1 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7
+  VDDPE VNWC VPW WRONE_0 WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6
+  WRONE_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1 RAMTP128X16CD_COLX_LT
XENDBOT_COL_LT DFTB DFT DWL DWL NSAE NYPCLK0A YPCLK0B NYPCLK1A YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 PRECHA PRECHB SAPRECH SEL_D SEL_SI SEL_TD RD_7 SO TE
+  TIELO_0 TIELO_1 TIELO_0 VDDCE_8 VDDPE VNWC VDDPE VPW VPW VSSE VPW VPW WCLK
+  WEN_7 RAMTP128X16ENDBOT_COL_LT
XRD_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6 RD_7 TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7 RAMTP128X16RD_COLX_L
XWR_COLX_LT DFTB D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2 RD_3 RD_4 RD_5
+  RD_6 RD_7 SEL_D SEL_SI SEL_TD SI_0 SO TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 TIELO_0 TE TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE VDDPE VPW WCLK WEN_7 WENY_0 WENY_1 WENY_2 WENY_3
+  WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6
+  WRONE_0 WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7 WRZERO_0
+  WRZERO_1 WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7
+  RAMTP128X16WR_COLX_L
XR_COLX_LT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7
+  WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMTP128X16XR_COLX_LT
.ENDS RAMTP128X16BOT_IO_LT
****
.SUBCKT RAMTP128X16CC2X2 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC
+  VDDCE VDDPE VNWC VPW VSS VSSE WLA0 WLA1 WLB0 WLB1
** RAMTP128X16CC2X2: 32 flat devices **
X_M_cc2x2_wl0_bl0.I34.MXNpdl NCORED_00 CORED_00 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXNpdr CORED_00 NCORED_00 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXNpgl_0 NBLB0 WLB0 NCORED_00 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgl_1 NBLA0 WLA0 NCORED_00 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgr_0 BLB0 WLB0 CORED_00 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXNpgr_1 BLA0 WLA0 CORED_00 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl0.I34.MXPpul NCORED_00 CORED_00 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl0.I34.MXPpur CORED_00 NCORED_00 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpdl NCORED_01 CORED_01 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpdr CORED_01 NCORED_01 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXNpgl_0 NBLB1 WLB0 NCORED_01 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgl_1 NBLA1 WLA0 NCORED_01 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgr_0 BLB1 WLB0 CORED_01 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXNpgr_1 BLA1 WLA0 CORED_01 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl0_bl1.I34.MXPpul NCORED_01 CORED_01 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl0_bl1.I34.MXPpur CORED_01 NCORED_01 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpdl NCORED_10 CORED_10 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpdr CORED_10 NCORED_10 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXNpgl_0 NBLB0 WLB1 NCORED_10 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgl_1 NBLA0 WLA1 NCORED_10 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgr_0 BLB0 WLB1 CORED_10 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXNpgr_1 BLA0 WLA1 CORED_10 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl0.I34.MXPpul NCORED_10 CORED_10 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl0.I34.MXPpur CORED_10 NCORED_10 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpdl NCORED_11 CORED_11 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpdr CORED_11 NCORED_11 VSSE VPW dpcnfetpd_ckt
+  W=0.305U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXNpgl_0 NBLB1 WLB1 NCORED_11 VPW dpcnfetwlb_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgl_1 NBLA1 WLA1 NCORED_11 VPW dpcnfetwla_ckt
+  W=0.154U L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgr_0 BLB1 WLB1 CORED_11 VPW dpcnfetwla_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXNpgr_1 BLA1 WLA1 CORED_11 VPW dpcnfetwlb_ckt W=0.154U
+  L=0.067U
X_M_cc2x2_wl1_bl1.I34.MXPpul NCORED_11 CORED_11 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
X_M_cc2x2_wl1_bl1.I34.MXPpur CORED_11 NCORED_11 VDDC VNWC dpcpfetpu_ckt
+  W=0.06U L=0.055U
.ENDS RAMTP128X16CC2X2
****
.SUBCKT RAMTP128X16CCCAPX2 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC
+  VDDCE VDDPE VNWC VPW VSS VSSE
** RAMTP128X16CCCAPX2: 24 flat devices **
X_MXN0 NET21 VPW NBLA0 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN1 VPW VPW NET044 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN11 NET041 NET023 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN12 VPW NET027 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN13 VPW NET055 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN14 NET057 NET059 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN2 VPW VPW NET046 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN23 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN24 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN25 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN3 NET25 VPW BLA0 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN34 VPW VPW NET42 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN35 VPW VPW NET46 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN4 NET33 VPW NBLA1 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN6 NET17 VPW BLA1 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN7 VSSE NET063 NET062 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN8 VSSE NET019 NET050 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXNpgl VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXP10 VNWC NET027 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP11 VNWC NET023 NET020 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP12 NET018 NET019 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP7 NET034 NET063 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP8 VNWC NET059 NET028 VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP9 VNWC NET055 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS RAMTP128X16CCCAPX2
****
.SUBCKT RAMTP128X16CC_COL_MUX1 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1
+  VDDC VDDPE VPW VSS WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7
+  WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16
+  WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25
+  WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3
+  WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13
+  WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22
+  WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5
+  WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15
+  WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24
+  WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16CC_COL_MUX1: 1072 flat devices **
XCC2X2_BOT BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC
+  VPW VSS VPW WLA0_0 WLA1_0 WLB0_0 WLB1_0 RAMTP128X16CC2X2
XCC2X2_TOP BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC
+  VPW VSS VPW WLA0_31 WLA1_31 WLB0_31 WLB1_31 RAMTP128X16CC2X2
XI0 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW RAMTP128X16CCCAPX2
XI10 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_8 WLA1_8 WLB0_8 WLB1_8 RAMTP128X16CC2X2
XI11 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_9 WLA1_9 WLB0_9 WLB1_9 RAMTP128X16CC2X2
XI12 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_10 WLA1_10 WLB0_10 WLB1_10 RAMTP128X16CC2X2
XI13 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_11 WLA1_11 WLB0_11 WLB1_11 RAMTP128X16CC2X2
XI14 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_12 WLA1_12 WLB0_12 WLB1_12 RAMTP128X16CC2X2
XI15 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_13 WLA1_13 WLB0_13 WLB1_13 RAMTP128X16CC2X2
XI16 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_14 WLA1_14 WLB0_14 WLB1_14 RAMTP128X16CC2X2
XI17 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_15 WLA1_15 WLB0_15 WLB1_15 RAMTP128X16CC2X2
XI18 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_16 WLA1_16 WLB0_16 WLB1_16 RAMTP128X16CC2X2
XI19 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_17 WLA1_17 WLB0_17 WLB1_17 RAMTP128X16CC2X2
XI20 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_18 WLA1_18 WLB0_18 WLB1_18 RAMTP128X16CC2X2
XI21 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_19 WLA1_19 WLB0_19 WLB1_19 RAMTP128X16CC2X2
XI22 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_20 WLA1_20 WLB0_20 WLB1_20 RAMTP128X16CC2X2
XI23 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_21 WLA1_21 WLB0_21 WLB1_21 RAMTP128X16CC2X2
XI24 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_22 WLA1_22 WLB0_22 WLB1_22 RAMTP128X16CC2X2
XI25 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_23 WLA1_23 WLB0_23 WLB1_23 RAMTP128X16CC2X2
XI26 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_24 WLA1_24 WLB0_24 WLB1_24 RAMTP128X16CC2X2
XI27 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_25 WLA1_25 WLB0_25 WLB1_25 RAMTP128X16CC2X2
XI28 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_26 WLA1_26 WLB0_26 WLB1_26 RAMTP128X16CC2X2
XI29 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_27 WLA1_27 WLB0_27 WLB1_27 RAMTP128X16CC2X2
XI3 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_1 WLA1_1 WLB0_1 WLB1_1 RAMTP128X16CC2X2
XI30 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_28 WLA1_28 WLB0_28 WLB1_28 RAMTP128X16CC2X2
XI31 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_29 WLA1_29 WLB0_29 WLB1_29 RAMTP128X16CC2X2
XI32 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_30 WLA1_30 WLB0_30 WLB1_30 RAMTP128X16CC2X2
XI34 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW RAMTP128X16CCCAPX2
XI4 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_2 WLA1_2 WLB0_2 WLB1_2 RAMTP128X16CC2X2
XI5 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_3 WLA1_3 WLB0_3 WLB1_3 RAMTP128X16CC2X2
XI6 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_4 WLA1_4 WLB0_4 WLB1_4 RAMTP128X16CC2X2
XI7 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_5 WLA1_5 WLB0_5 WLB1_5 RAMTP128X16CC2X2
XI8 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_6 WLA1_6 WLB0_6 WLB1_6 RAMTP128X16CC2X2
XI9 BLA0 BLA1 BLB0 BLB1 NBLA0 NBLA1 NBLB0 NBLB1 VDDC VDDC VDDPE VDDC VPW VSS
+  VPW WLA0_7 WLA1_7 WLB0_7 WLB1_7 RAMTP128X16CC2X2
.ENDS RAMTP128X16CC_COL_MUX1
****
.SUBCKT RAMTP128X16CORE_COLX_L BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1
+  BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5
+  NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6
+  NBLB1_7 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WLA0_0 WLA0_1
+  WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11
+  WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20
+  WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29
+  WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7
+  WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16
+  WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25
+  WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3
+  WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13
+  WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22
+  WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31
+  WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16CORE_COLX_L: 8576 flat devices **
XCC2X2_COL_FARWD BLA0_7 BLA1_7 BLB0_7 BLB1_7 NBLA0_7 NBLA1_7 NBLB0_7 NBLB1_7
+  VDDC VDDPE_7 VPW VSS_7 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XCC2X2_COL_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 NBLA0_0 NBLA1_0 NBLB0_0 NBLB1_0
+  VDDC VDDPE_0 VPW VSS_0 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_1 BLA0_1 BLA1_1 BLB0_1 BLB1_1 NBLA0_1 NBLA1_1 NBLB0_1 NBLB1_1
+  VDDC VDDPE_1 VPW VSS_1 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  VDDC VDDPE_2 VPW VSS_2 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  VDDC VDDPE_3 VPW VSS_3 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  VDDC VDDPE_4 VPW VSS_4 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  VDDC VDDPE_5 VPW VSS_5 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XLCC_COL_MUX1_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  VDDC VDDPE_6 VPW VSS_6 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
.ENDS RAMTP128X16CORE_COLX_L
****
.SUBCKT RAMTP128X16CORE_COLXL BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5
+  WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15
+  WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24
+  WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1
+  WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11
+  WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20
+  WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29
+  WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7
+  WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16
+  WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25
+  WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16CORE_COLXL: 8576 flat devices **
XCORE_COLXS_L BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5
+  NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6
+  NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CORE_COLX_L
.ENDS RAMTP128X16CORE_COLXL
****
.SUBCKT RAMTP128X16FPCTRL_OPT CAA0 CAA1 CAB0 CAB1 CAYA0 CAYA1 CAYB0 CAYB1 CENA
+  CENB CENYA CENYB CLKA CLKB COLLDISN CRE1 CRE2 DFTRAMBYP EMAA0 EMAA1 EMAA2
+  EMAB0 EMAB1 EMAB2 FCA1_0 FCA1_1 FCA1_2 FCA1_3 FCA1_4 FCA1_5 FCA1_6 FCA2_0
+  FCA2_1 FCA2_2 FCA2_3 FCA2_4 FCA2_5 FCA2_6 LAA0 LAA1 LAB0 LAB1 LAYA0 LAYA1
+  LAYB0 LAYB1 PENA PENSIA PENSOA PGEN PSIA0 PSIA1 RAA0 RAA1 RAA2 RAA3 RAA4
+  RAA5 RAB0 RAB1 RAB2 RAB3 RAB4 RAB5 RAYA0 RAYA1 RAYA2 RAYA3 RAYA4 RAYA5
+  RAYB0 RAYB1 RAYB2 RAYB3 RAYB4 RAYB5 RDT RET1N RET2N SEA SEB SIA0 SIA1 SIB0
+  SIB1 TCAA0 TCAA1 TCAB0 TCAB1 TCENA TCENB TENA TENB TIELOFPA TIELOFPB TLAA0
+  TLAA1 TLAB0 TLAB1 TPENA TRAA0 TRAA1 TRAA2 TRAA3 TRAA4 TRAA5 TRAB0 TRAB1
+  TRAB2 TRAB3 TRAB4 TRAB5 VDDCE VDDPE VNWC VNWP VPW VSS VSSE
** RAMTP128X16FPCTRL_OPT: 87 flat devices **
D_Diode_XD0_0 VPW SIA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD0_1 VPW SIA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD0_2 VPW SEA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD0_3 VPW TENA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD0_4 VPW TCENA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD0_5 VPW CENA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_0 VPW FCA1_0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_1 VPW FCA1_1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_2 VPW FCA1_2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_3 VPW FCA1_3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_4 VPW FCA1_4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_5 VPW FCA1_5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD11_6 VPW FCA1_6 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD12_0 VPW DFTRAMBYP NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD12_1 VPW COLLDISN NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD13_0 VPW CRE2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD13_1 VPW CRE1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD14_0 VPW PSIA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD14_1 VPW PSIA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD14_2 VPW TPENA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD14_3 VPW PENA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD14_4 VPW PENSIA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_0 VPW CAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_1 VPW CAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_2 VPW LAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_3 VPW LAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_4 VPW RAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_5 VPW RAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_6 VPW RAA2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_7 VPW RAA3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_8 VPW RAA4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD1_9 VPW RAA5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_0 VPW TCAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_1 VPW TCAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_2 VPW TLAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_3 VPW TLAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_4 VPW TRAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_5 VPW TRAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_6 VPW TRAA2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_7 VPW TRAA3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_8 VPW TRAA4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD2_9 VPW TRAA5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD3_0 VPW CLKA NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD3_1 VPW RDT NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD3_2 VPW EMAA0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD3_3 VPW EMAA1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD3_4 VPW EMAA2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_0 VPW CAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_1 VPW CAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_2 VPW LAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_3 VPW LAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_4 VPW RAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_5 VPW RAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_6 VPW RAB2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_7 VPW RAB3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_8 VPW RAB4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD4_9 VPW RAB5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD5_0 VPW PGEN NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD5_1 VPW RET1N NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD5_2 VPW RET2N NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_0 VPW TENB NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_1 VPW SIB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_2 VPW SIB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_3 VPW SEB NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_4 VPW TCENB NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD6_5 VPW CENB NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_0 VPW TCAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_1 VPW TCAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_2 VPW TLAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_3 VPW TLAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_4 VPW TRAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_5 VPW TRAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_6 VPW TRAB2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_7 VPW TRAB3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_8 VPW TRAB4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD7_9 VPW TRAB5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD8_0 VPW CLKB NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD8_1 VPW EMAB0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD8_2 VPW EMAB1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD8_3 VPW EMAB2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_0 VPW FCA2_0 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_1 VPW FCA2_1 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_2 VPW FCA2_2 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_3 VPW FCA2_3 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_4 VPW FCA2_4 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_5 VPW FCA2_5 NDIO11LL AREA=0.035P PJ=0.66U
D_Diode_XD9_6 VPW FCA2_6 NDIO11LL AREA=0.035P PJ=0.66U
.ENDS RAMTP128X16FPCTRL_OPT
****
.SUBCKT RAMTP128X16CKM2_BSTWM CAA0 CAA1 CAB0 CAB1 CAYA0 CAYA1 CAYB0 CAYB1 CENA
+  CENB CENYA CENYB CLKA CLKB COLLDISN DBLA DBLB DFTRAMBYP DFTRETA DFTRETB
+  DWLA DWLATURN DWLAV DWLB DWLBTURN DWLBV EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2
+  GTPA GTPB IDFT IDFTA_P2 ISAE_DUM0 ISAE_DUM1 ISIA0 ISIA1 ITEB LAA0 LAA1
+  LAA_P2[0] LAA_P2[1] LAB0 LAB1 LAB_P2[0] LAB_P2[1] LAYA0 LAYA1 LAYB0 LAYB1
+  NACTC NRETNVT NSAE NYPACLK[0] NYPACLK[1] PRECHA_L PRECHA_R PRECHB_L
+  PRECHB_R RAA0 RAA1 RAA2 RAA3 RAA4 RAA5 RAA_P2[0] RAA_P2[1] RAA_P2[2]
+  RAA_P2[3] RAA_P2[4] RAA_P2[5] RAB0 RAB1 RAB2 RAB3 RAB4 RAB5 RAB_P2[0]
+  RAB_P2[1] RAB_P2[2] RAB_P2[3] RAB_P2[4] RAB_P2[5] RAYA0 RAYA1 RAYA2 RAYA3
+  RAYA4 RAYA5 RAYB0 RAYB1 RAYB2 RAYB3 RAYB4 RAYB5 RDT RET1N SAEDIN SAEDO0
+  SAEDO1 SAE_DUMMY SAPRECH SEA SEB SEL_D SEL_SIB SEL_TD SIA0 SIA1 SIB0 SIB1
+  TCAA0 TCAA1 TCAB0 TCAB1 TCENA TCENB TENA TENB TIEHIA TIEHIB TIELOCDA
+  TIELOCDB TIELODBLA TIELODBLB TIELOFPA TIELOFPB TLAA0 TLAA1 TLAB0 TLAB1
+  TRAA0 TRAA1 TRAA2 TRAA3 TRAA4 TRAA5 TRAB0 TRAB1 TRAB2 TRAB3 TRAB4 TRAB5
+  TWEN VDDCE VDDC_WLA VDDC_WLB VDDPE VDDP_DWLA VDDP_DWLB VNWC VNWP VPW VSS
+  VSSE WCLK WEN WENSHF1TERM WENSHF2TERM YPBCLK[0] YPBCLK[1] YPCOL[0] YPCOL[1]
** RAMTP128X16CKM2_BSTWM: 1441 flat devices **
X_MI0.MXNA1 NET308 DFTRAMBYP VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI0.MXPA1 NET308 DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.99U L=0.04U
X_MI1.MXNA1 ITENB NET320 VSS VPW N11LL_CKT W=0.74U L=0.04U
X_MI1.MXPA1 ITENB NET320 VDDPE VNWP P11LL_CKT W=1.075U L=0.04U
X_MI10.MXNA1 ITENA NET284 VSS VPW N11LL_CKT W=0.23U L=0.04U
X_MI10.MXPA1 ITENA NET284 VDDPE VNWP P11LL_CKT W=0.34U L=0.04U
X_MI15.MXNA1 NET273 SIA0 I15.N1 VPW N11LL_CKT W=0.155U L=0.04U
X_MI15.MXNA2 I15.N1 SEA VSS VPW N11LL_CKT W=0.155U L=0.04U
X_MI15.MXPA1 NET273 SIA0 VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_MI15.MXPA2 NET273 SEA VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_MI1521.MXNA1 BCENA NET0213 VSS VPW N11LL_CKT W=0.71U L=0.04U
X_MI1521.MXPA1 BCENA NET0213 VDDPE VNWP P11LL_CKT W=1.21U L=0.04U
X_MI17.MXNA1 ISIA1 NET0284 VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI17.MXPA1 ISIA1 NET0284 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI18.MXNA1 ISIA0 NET0303 VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI18.MXPA1 ISIA0 NET0303 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI19.MXNA1 NET0303 NET273 VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI19.MXPA1 NET0303 NET273 VDDPE VNWP P11LL_CKT W=0.26U L=0.04U
X_MI2.MXNA1 ITEB ITENB VSS VPW N11LL_CKT W=3.7U L=0.04U
X_MI2.MXPA1 ITEB ITENB VDDPE VNWP P11LL_CKT W=5.375U L=0.04U
X_MI20.MXNA1 NET0284 NET0285 VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI20.MXPA1 NET0284 NET0285 VDDPE VNWP P11LL_CKT W=0.26U L=0.04U
X_MI21.MXNA1 NDYA BCENA I21.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI21.MXNA2 I21.N1 IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MI21.MXPA1 NDYA BCENA VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI21.MXPA2 NDYA IDFT VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI22.MXNA1 NDYB BCENB I22.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MI22.MXNA2 I22.N1 IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MI22.MXPA1 NDYB BCENB VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI22.MXPA2 NDYB IDFT VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI23.MXNA1 CENYB NDYB VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MI23.MXPA1 CENYB NDYB VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MI24.MXNA1 BCENB NET0232 VSS VPW N11LL_CKT W=0.71U L=0.04U
X_MI24.MXPA1 BCENB NET0232 VDDPE VNWP P11LL_CKT W=1.205U L=0.04U
X_MI30.MXNA1 IDFTA_P2 NET0430 VSS VPW N11LL_CKT W=2.8U L=0.04U
X_MI30.MXPA1 IDFTA_P2 NET0430 VDDPE VNWP P11LL_CKT W=4.8U L=0.04U
X_MI31.MXNA1 NET0430 DFTA_P2 VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MI31.MXPA1 NET0430 DFTA_P2 VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI32.MXNA1 IDFT NET308 VSS VPW N11LL_CKT W=2.975U L=0.04U
X_MI32.MXPA1 IDFT NET308 VDDPE VNWP P11LL_CKT W=5.1U L=0.04U
X_MI36.MXNA1 MOD_COLDISN MOD_RDT_P2 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI36.MXNA2 MOD_COLDISN NET0387 VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI36.MXPA1 MOD_COLDISN MOD_RDT_P2 I36.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_MI36.MXPA2 I36.P1 NET0387 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI39.MXNA1 NIDFTB_P2 IDFTB_P2 VSS VPW N11LL_CKT W=0.155U L=0.04U
X_MI39.MXPA1 NIDFTB_P2 IDFTB_P2 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI5.MXNA1 NET320 TENB VSS VPW N11LL_CKT W=0.16U L=0.04U
X_MI5.MXPA1 NET320 TENB VDDPE VNWP P11LL_CKT W=0.255U L=0.04U
X_MI62.MXNA1 CENYA NDYA VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MI62.MXPA1 CENYA NDYA VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MI7.MXNA1 NET0387 NIDFTB_P2 I7.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.MXNA2 I7.N1 COLLDISN VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI7.MXPA1 NET0387 NIDFTB_P2 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI7.MXPA2 NET0387 COLLDISN VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI77.MXNA1 NET0285 SIA1 I77.N1 VPW N11LL_CKT W=0.155U L=0.04U
X_MI77.MXNA2 I77.N1 SEA VSS VPW N11LL_CKT W=0.155U L=0.04U
X_MI77.MXPA1 NET0285 SIA1 VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_MI77.MXPA2 NET0285 SEA VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_MI8.MXNA1 NET284 TENA VSS VPW N11LL_CKT W=0.155U L=0.04U
X_MI8.MXPA1 NET284 TENA VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI9.MXNA1 ITEA ITENA VSS VPW N11LL_CKT W=1U L=0.04U
X_MI9.MXPA1 ITEA ITENA VDDPE VNWP P11LL_CKT W=1.7U L=0.04U
X_MXN0 N1B ITENB VSS VPW N11LL_CKT W=0.395U L=0.04U
X_MXN1 NET0213 TCENA N2A VPW N11LL_CKT W=0.395U L=0.04U
X_MXN2 NET0213 CENA N1A VPW N11LL_CKT W=0.395U L=0.04U
X_MXN3 NET0232 CENB N1B VPW N11LL_CKT W=0.395U L=0.04U
X_MXN4 NET0232 TCENB N2B VPW N11LL_CKT W=0.395U L=0.04U
X_MXN5 N1A ITENA VSS VPW N11LL_CKT W=0.395U L=0.04U
X_MXN6 N2A ITEA VSS VPW N11LL_CKT W=0.395U L=0.04U
X_MXN7 N2B ITEB VSS VPW N11LL_CKT W=0.395U L=0.04U
X_MXP0 P2B ITENB VDDPE VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP1 NET0213 CENA P1A VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP2 P1B ITEB VDDPE VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP3 NET0213 TCENA P2A VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP4 P1A ITEA VDDPE VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP5 P2A ITENA VDDPE VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP6 NET0232 TCENB P2B VNWP P11LL_CKT W=0.625U L=0.04U
X_MXP7 NET0232 CENB P1B VNWP P11LL_CKT W=0.625U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I0.MXNA1 _ADDLATA._CADD_LAT_0._BSTADD.NDY
+  _ADDLATA._CADD_LAT_0._BSTADD.IDY _ADDLATA._CADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I0.MXNA2 _ADDLATA._CADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I0.MXPA1 _ADDLATA._CADD_LAT_0._BSTADD.NDY
+  _ADDLATA._CADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I0.MXPA2 _ADDLATA._CADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I50.MXNA1 CAA_P2[0] _ADDLATA.NCA_P2[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I50.MXPA1 CAA_P2[0] _ADDLATA.NCA_P2[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I55.MXNA1 _ADDLATA._CADD_LAT_0._BSTADD.I55.N1
+  CAA_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I55.MXNOE _ADDLATA.NCA_P2[0] BCLKA
+  _ADDLATA._CADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I55.MXPA1 _ADDLATA._CADD_LAT_0._BSTADD.I55.P1
+  CAA_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I55.MXPOEN _ADDLATA.NCA_P2[0] NCLKA
+  _ADDLATA._CADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I57.MXNA1 _ADDLATA._CADD_LAT_0._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I57.MXPA1 _ADDLATA._CADD_LAT_0._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I62.MXNA1 CAYA0
+  _ADDLATA._CADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I62.MXPA1 CAYA0
+  _ADDLATA._CADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I63.MXNA1 _ADDLATA._CADD_LAT_0._BSTADD.IDY
+  _ADDLATA._CADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I63.MXPA1 _ADDLATA._CADD_LAT_0._BSTADD.IDY
+  _ADDLATA._CADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I65.MXNOE _ADDLATA.NCA_P2[0] NCLKA
+  _ADDLATA._CADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.I65.MXPOEN _ADDLATA.NCA_P2[0] BCLKA
+  _ADDLATA._CADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXN1 _ADDLATA._CADD_LAT_0._BSTADD.ND TCAA0
+  _ADDLATA._CADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXN2 _ADDLATA._CADD_LAT_0._BSTADD.ND CAA0
+  _ADDLATA._CADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXN5 _ADDLATA._CADD_LAT_0._BSTADD.N1
+  _ADDLATA._CADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXN6 _ADDLATA._CADD_LAT_0._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXP1 _ADDLATA._CADD_LAT_0._BSTADD.ND CAA0
+  _ADDLATA._CADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXP3 _ADDLATA._CADD_LAT_0._BSTADD.ND TCAA0
+  _ADDLATA._CADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXP4 _ADDLATA._CADD_LAT_0._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_0._bstadd.MXP5 _ADDLATA._CADD_LAT_0._BSTADD.P2
+  _ADDLATA._CADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I0.MXNA1 _ADDLATA._CADD_LAT_1._BSTADD.NDY
+  _ADDLATA._CADD_LAT_1._BSTADD.IDY _ADDLATA._CADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I0.MXNA2 _ADDLATA._CADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I0.MXPA1 _ADDLATA._CADD_LAT_1._BSTADD.NDY
+  _ADDLATA._CADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I0.MXPA2 _ADDLATA._CADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I50.MXNA1 CAA_P2[1] _ADDLATA.NCA_P2[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I50.MXPA1 CAA_P2[1] _ADDLATA.NCA_P2[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I55.MXNA1 _ADDLATA._CADD_LAT_1._BSTADD.I55.N1
+  CAA_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I55.MXNOE _ADDLATA.NCA_P2[1] BCLKA
+  _ADDLATA._CADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I55.MXPA1 _ADDLATA._CADD_LAT_1._BSTADD.I55.P1
+  CAA_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I55.MXPOEN _ADDLATA.NCA_P2[1] NCLKA
+  _ADDLATA._CADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I57.MXNA1 _ADDLATA._CADD_LAT_1._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I57.MXPA1 _ADDLATA._CADD_LAT_1._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I62.MXNA1 CAYA1
+  _ADDLATA._CADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I62.MXPA1 CAYA1
+  _ADDLATA._CADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I63.MXNA1 _ADDLATA._CADD_LAT_1._BSTADD.IDY
+  _ADDLATA._CADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I63.MXPA1 _ADDLATA._CADD_LAT_1._BSTADD.IDY
+  _ADDLATA._CADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I65.MXNOE _ADDLATA.NCA_P2[1] NCLKA
+  _ADDLATA._CADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.I65.MXPOEN _ADDLATA.NCA_P2[1] BCLKA
+  _ADDLATA._CADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXN1 _ADDLATA._CADD_LAT_1._BSTADD.ND TCAA1
+  _ADDLATA._CADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXN2 _ADDLATA._CADD_LAT_1._BSTADD.ND CAA1
+  _ADDLATA._CADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXN5 _ADDLATA._CADD_LAT_1._BSTADD.N1
+  _ADDLATA._CADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXN6 _ADDLATA._CADD_LAT_1._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXP1 _ADDLATA._CADD_LAT_1._BSTADD.ND CAA1
+  _ADDLATA._CADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXP3 _ADDLATA._CADD_LAT_1._BSTADD.ND TCAA1
+  _ADDLATA._CADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXP4 _ADDLATA._CADD_LAT_1._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._cadd_lat_1._bstadd.MXP5 _ADDLATA._CADD_LAT_1._BSTADD.P2
+  _ADDLATA._CADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I0.MXNA1 _ADDLATA._LADD_LAT_0._BSTADD.NDY
+  _ADDLATA._LADD_LAT_0._BSTADD.IDY _ADDLATA._LADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I0.MXNA2 _ADDLATA._LADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I0.MXPA1 _ADDLATA._LADD_LAT_0._BSTADD.NDY
+  _ADDLATA._LADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I0.MXPA2 _ADDLATA._LADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I50.MXNA1 LAA_P2[0] _ADDLATA.NET48[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I50.MXPA1 LAA_P2[0] _ADDLATA.NET48[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I55.MXNA1 _ADDLATA._LADD_LAT_0._BSTADD.I55.N1
+  LAA_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I55.MXNOE _ADDLATA.NET48[1] BCLKA
+  _ADDLATA._LADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I55.MXPA1 _ADDLATA._LADD_LAT_0._BSTADD.I55.P1
+  LAA_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I55.MXPOEN _ADDLATA.NET48[1] NCLKA
+  _ADDLATA._LADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I57.MXNA1 _ADDLATA._LADD_LAT_0._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I57.MXPA1 _ADDLATA._LADD_LAT_0._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I62.MXNA1 LAYA0
+  _ADDLATA._LADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I62.MXPA1 LAYA0
+  _ADDLATA._LADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I63.MXNA1 _ADDLATA._LADD_LAT_0._BSTADD.IDY
+  _ADDLATA._LADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I63.MXPA1 _ADDLATA._LADD_LAT_0._BSTADD.IDY
+  _ADDLATA._LADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I65.MXNOE _ADDLATA.NET48[1] NCLKA
+  _ADDLATA._LADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.I65.MXPOEN _ADDLATA.NET48[1] BCLKA
+  _ADDLATA._LADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXN1 _ADDLATA._LADD_LAT_0._BSTADD.ND TLAA0
+  _ADDLATA._LADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXN2 _ADDLATA._LADD_LAT_0._BSTADD.ND LAA0
+  _ADDLATA._LADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXN5 _ADDLATA._LADD_LAT_0._BSTADD.N1
+  _ADDLATA._LADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXN6 _ADDLATA._LADD_LAT_0._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXP1 _ADDLATA._LADD_LAT_0._BSTADD.ND LAA0
+  _ADDLATA._LADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXP3 _ADDLATA._LADD_LAT_0._BSTADD.ND TLAA0
+  _ADDLATA._LADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXP4 _ADDLATA._LADD_LAT_0._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_0._bstadd.MXP5 _ADDLATA._LADD_LAT_0._BSTADD.P2
+  _ADDLATA._LADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I0.MXNA1 _ADDLATA._LADD_LAT_1._BSTADD.NDY
+  _ADDLATA._LADD_LAT_1._BSTADD.IDY _ADDLATA._LADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I0.MXNA2 _ADDLATA._LADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I0.MXPA1 _ADDLATA._LADD_LAT_1._BSTADD.NDY
+  _ADDLATA._LADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I0.MXPA2 _ADDLATA._LADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I50.MXNA1 LAA_P2[1] _ADDLATA.NET48[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I50.MXPA1 LAA_P2[1] _ADDLATA.NET48[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I55.MXNA1 _ADDLATA._LADD_LAT_1._BSTADD.I55.N1
+  LAA_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I55.MXNOE _ADDLATA.NET48[0] BCLKA
+  _ADDLATA._LADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I55.MXPA1 _ADDLATA._LADD_LAT_1._BSTADD.I55.P1
+  LAA_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I55.MXPOEN _ADDLATA.NET48[0] NCLKA
+  _ADDLATA._LADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I57.MXNA1 _ADDLATA._LADD_LAT_1._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I57.MXPA1 _ADDLATA._LADD_LAT_1._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I62.MXNA1 LAYA1
+  _ADDLATA._LADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I62.MXPA1 LAYA1
+  _ADDLATA._LADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I63.MXNA1 _ADDLATA._LADD_LAT_1._BSTADD.IDY
+  _ADDLATA._LADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I63.MXPA1 _ADDLATA._LADD_LAT_1._BSTADD.IDY
+  _ADDLATA._LADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I65.MXNOE _ADDLATA.NET48[0] NCLKA
+  _ADDLATA._LADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.I65.MXPOEN _ADDLATA.NET48[0] BCLKA
+  _ADDLATA._LADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXN1 _ADDLATA._LADD_LAT_1._BSTADD.ND TLAA1
+  _ADDLATA._LADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXN2 _ADDLATA._LADD_LAT_1._BSTADD.ND LAA1
+  _ADDLATA._LADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXN5 _ADDLATA._LADD_LAT_1._BSTADD.N1
+  _ADDLATA._LADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXN6 _ADDLATA._LADD_LAT_1._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXP1 _ADDLATA._LADD_LAT_1._BSTADD.ND LAA1
+  _ADDLATA._LADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXP3 _ADDLATA._LADD_LAT_1._BSTADD.ND TLAA1
+  _ADDLATA._LADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXP4 _ADDLATA._LADD_LAT_1._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._ladd_lat_1._bstadd.MXP5 _ADDLATA._LADD_LAT_1._BSTADD.P2
+  _ADDLATA._LADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_0._BSTADD.NDY
+  _ADDLATA._RADD_LAT_0._BSTADD.IDY _ADDLATA._RADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_0._BSTADD.NDY
+  _ADDLATA._RADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I50.MXNA1 RAA_P2[0] _ADDLATA.NET27[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I50.MXPA1 RAA_P2[0] _ADDLATA.NET27[2] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_0._BSTADD.I55.N1
+  RAA_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I55.MXNOE _ADDLATA.NET27[2] BCLKA
+  _ADDLATA._RADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_0._BSTADD.I55.P1
+  RAA_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I55.MXPOEN _ADDLATA.NET27[2] NCLKA
+  _ADDLATA._RADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_0._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_0._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I62.MXNA1 RAYA0
+  _ADDLATA._RADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I62.MXPA1 RAYA0
+  _ADDLATA._RADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_0._BSTADD.IDY
+  _ADDLATA._RADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_0._BSTADD.IDY
+  _ADDLATA._RADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I65.MXNOE _ADDLATA.NET27[2] NCLKA
+  _ADDLATA._RADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_0._bstadd.I65.MXPOEN _ADDLATA.NET27[2] BCLKA
+  _ADDLATA._RADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXN1 _ADDLATA._RADD_LAT_0._BSTADD.ND TRAA0
+  _ADDLATA._RADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXN2 _ADDLATA._RADD_LAT_0._BSTADD.ND RAA0
+  _ADDLATA._RADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXN5 _ADDLATA._RADD_LAT_0._BSTADD.N1
+  _ADDLATA._RADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXN6 _ADDLATA._RADD_LAT_0._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXP1 _ADDLATA._RADD_LAT_0._BSTADD.ND RAA0
+  _ADDLATA._RADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXP3 _ADDLATA._RADD_LAT_0._BSTADD.ND TRAA0
+  _ADDLATA._RADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXP4 _ADDLATA._RADD_LAT_0._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_0._bstadd.MXP5 _ADDLATA._RADD_LAT_0._BSTADD.P2
+  _ADDLATA._RADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_1._BSTADD.NDY
+  _ADDLATA._RADD_LAT_1._BSTADD.IDY _ADDLATA._RADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_1._BSTADD.NDY
+  _ADDLATA._RADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I50.MXNA1 RAA_P2[1] _ADDLATA.NET27[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I50.MXPA1 RAA_P2[1] _ADDLATA.NET27[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_1._BSTADD.I55.N1
+  RAA_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I55.MXNOE _ADDLATA.NET27[1] BCLKA
+  _ADDLATA._RADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_1._BSTADD.I55.P1
+  RAA_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I55.MXPOEN _ADDLATA.NET27[1] NCLKA
+  _ADDLATA._RADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_1._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_1._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I62.MXNA1 RAYA1
+  _ADDLATA._RADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I62.MXPA1 RAYA1
+  _ADDLATA._RADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_1._BSTADD.IDY
+  _ADDLATA._RADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_1._BSTADD.IDY
+  _ADDLATA._RADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I65.MXNOE _ADDLATA.NET27[1] NCLKA
+  _ADDLATA._RADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_1._bstadd.I65.MXPOEN _ADDLATA.NET27[1] BCLKA
+  _ADDLATA._RADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXN1 _ADDLATA._RADD_LAT_1._BSTADD.ND TRAA1
+  _ADDLATA._RADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXN2 _ADDLATA._RADD_LAT_1._BSTADD.ND RAA1
+  _ADDLATA._RADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXN5 _ADDLATA._RADD_LAT_1._BSTADD.N1
+  _ADDLATA._RADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXN6 _ADDLATA._RADD_LAT_1._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXP1 _ADDLATA._RADD_LAT_1._BSTADD.ND RAA1
+  _ADDLATA._RADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXP3 _ADDLATA._RADD_LAT_1._BSTADD.ND TRAA1
+  _ADDLATA._RADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXP4 _ADDLATA._RADD_LAT_1._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_1._bstadd.MXP5 _ADDLATA._RADD_LAT_1._BSTADD.P2
+  _ADDLATA._RADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_2._BSTADD.NDY
+  _ADDLATA._RADD_LAT_2._BSTADD.IDY _ADDLATA._RADD_LAT_2._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_2._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_2._BSTADD.NDY
+  _ADDLATA._RADD_LAT_2._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_2._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I50.MXNA1 RAA_P2[2] _ADDLATA.NET27[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I50.MXPA1 RAA_P2[2] _ADDLATA.NET27[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_2._BSTADD.I55.N1
+  RAA_P2[2] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I55.MXNOE _ADDLATA.NET27[0] BCLKA
+  _ADDLATA._RADD_LAT_2._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_2._BSTADD.I55.P1
+  RAA_P2[2] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I55.MXPOEN _ADDLATA.NET27[0] NCLKA
+  _ADDLATA._RADD_LAT_2._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_2._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_2._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I62.MXNA1 RAYA2
+  _ADDLATA._RADD_LAT_2._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I62.MXPA1 RAYA2
+  _ADDLATA._RADD_LAT_2._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_2._BSTADD.IDY
+  _ADDLATA._RADD_LAT_2._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_2._BSTADD.IDY
+  _ADDLATA._RADD_LAT_2._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I65.MXNOE _ADDLATA.NET27[0] NCLKA
+  _ADDLATA._RADD_LAT_2._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_2._bstadd.I65.MXPOEN _ADDLATA.NET27[0] BCLKA
+  _ADDLATA._RADD_LAT_2._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXN1 _ADDLATA._RADD_LAT_2._BSTADD.ND TRAA2
+  _ADDLATA._RADD_LAT_2._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXN2 _ADDLATA._RADD_LAT_2._BSTADD.ND RAA2
+  _ADDLATA._RADD_LAT_2._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXN5 _ADDLATA._RADD_LAT_2._BSTADD.N1
+  _ADDLATA._RADD_LAT_2._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXN6 _ADDLATA._RADD_LAT_2._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXP1 _ADDLATA._RADD_LAT_2._BSTADD.ND RAA2
+  _ADDLATA._RADD_LAT_2._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXP3 _ADDLATA._RADD_LAT_2._BSTADD.ND TRAA2
+  _ADDLATA._RADD_LAT_2._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXP4 _ADDLATA._RADD_LAT_2._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_2._bstadd.MXP5 _ADDLATA._RADD_LAT_2._BSTADD.P2
+  _ADDLATA._RADD_LAT_2._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_3._BSTADD.NDY
+  _ADDLATA._RADD_LAT_3._BSTADD.IDY _ADDLATA._RADD_LAT_3._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_3._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_3._BSTADD.NDY
+  _ADDLATA._RADD_LAT_3._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_3._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I50.MXNA1 RAA_P2[3] _ADDLATA.NET18[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I50.MXPA1 RAA_P2[3] _ADDLATA.NET18[2] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_3._BSTADD.I55.N1
+  RAA_P2[3] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I55.MXNOE _ADDLATA.NET18[2] BCLKA
+  _ADDLATA._RADD_LAT_3._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_3._BSTADD.I55.P1
+  RAA_P2[3] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I55.MXPOEN _ADDLATA.NET18[2] NCLKA
+  _ADDLATA._RADD_LAT_3._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_3._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_3._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I62.MXNA1 RAYA3
+  _ADDLATA._RADD_LAT_3._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I62.MXPA1 RAYA3
+  _ADDLATA._RADD_LAT_3._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_3._BSTADD.IDY
+  _ADDLATA._RADD_LAT_3._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_3._BSTADD.IDY
+  _ADDLATA._RADD_LAT_3._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I65.MXNOE _ADDLATA.NET18[2] NCLKA
+  _ADDLATA._RADD_LAT_3._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_3._bstadd.I65.MXPOEN _ADDLATA.NET18[2] BCLKA
+  _ADDLATA._RADD_LAT_3._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXN1 _ADDLATA._RADD_LAT_3._BSTADD.ND TRAA3
+  _ADDLATA._RADD_LAT_3._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXN2 _ADDLATA._RADD_LAT_3._BSTADD.ND RAA3
+  _ADDLATA._RADD_LAT_3._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXN5 _ADDLATA._RADD_LAT_3._BSTADD.N1
+  _ADDLATA._RADD_LAT_3._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXN6 _ADDLATA._RADD_LAT_3._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXP1 _ADDLATA._RADD_LAT_3._BSTADD.ND RAA3
+  _ADDLATA._RADD_LAT_3._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXP3 _ADDLATA._RADD_LAT_3._BSTADD.ND TRAA3
+  _ADDLATA._RADD_LAT_3._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXP4 _ADDLATA._RADD_LAT_3._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_3._bstadd.MXP5 _ADDLATA._RADD_LAT_3._BSTADD.P2
+  _ADDLATA._RADD_LAT_3._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_4._BSTADD.NDY
+  _ADDLATA._RADD_LAT_4._BSTADD.IDY _ADDLATA._RADD_LAT_4._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_4._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_4._BSTADD.NDY
+  _ADDLATA._RADD_LAT_4._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_4._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I50.MXNA1 RAA_P2[4] _ADDLATA.NET18[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I50.MXPA1 RAA_P2[4] _ADDLATA.NET18[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_4._BSTADD.I55.N1
+  RAA_P2[4] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I55.MXNOE _ADDLATA.NET18[1] BCLKA
+  _ADDLATA._RADD_LAT_4._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_4._BSTADD.I55.P1
+  RAA_P2[4] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I55.MXPOEN _ADDLATA.NET18[1] NCLKA
+  _ADDLATA._RADD_LAT_4._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_4._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_4._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I62.MXNA1 RAYA4
+  _ADDLATA._RADD_LAT_4._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I62.MXPA1 RAYA4
+  _ADDLATA._RADD_LAT_4._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_4._BSTADD.IDY
+  _ADDLATA._RADD_LAT_4._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_4._BSTADD.IDY
+  _ADDLATA._RADD_LAT_4._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I65.MXNOE _ADDLATA.NET18[1] NCLKA
+  _ADDLATA._RADD_LAT_4._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_4._bstadd.I65.MXPOEN _ADDLATA.NET18[1] BCLKA
+  _ADDLATA._RADD_LAT_4._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXN1 _ADDLATA._RADD_LAT_4._BSTADD.ND TRAA4
+  _ADDLATA._RADD_LAT_4._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXN2 _ADDLATA._RADD_LAT_4._BSTADD.ND RAA4
+  _ADDLATA._RADD_LAT_4._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXN5 _ADDLATA._RADD_LAT_4._BSTADD.N1
+  _ADDLATA._RADD_LAT_4._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXN6 _ADDLATA._RADD_LAT_4._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXP1 _ADDLATA._RADD_LAT_4._BSTADD.ND RAA4
+  _ADDLATA._RADD_LAT_4._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXP3 _ADDLATA._RADD_LAT_4._BSTADD.ND TRAA4
+  _ADDLATA._RADD_LAT_4._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXP4 _ADDLATA._RADD_LAT_4._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_4._bstadd.MXP5 _ADDLATA._RADD_LAT_4._BSTADD.P2
+  _ADDLATA._RADD_LAT_4._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I0.MXNA1 _ADDLATA._RADD_LAT_5._BSTADD.NDY
+  _ADDLATA._RADD_LAT_5._BSTADD.IDY _ADDLATA._RADD_LAT_5._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I0.MXNA2 _ADDLATA._RADD_LAT_5._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I0.MXPA1 _ADDLATA._RADD_LAT_5._BSTADD.NDY
+  _ADDLATA._RADD_LAT_5._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I0.MXPA2 _ADDLATA._RADD_LAT_5._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I50.MXNA1 RAA_P2[5] _ADDLATA.NET18[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I50.MXPA1 RAA_P2[5] _ADDLATA.NET18[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I55.MXNA1 _ADDLATA._RADD_LAT_5._BSTADD.I55.N1
+  RAA_P2[5] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I55.MXNOE _ADDLATA.NET18[0] BCLKA
+  _ADDLATA._RADD_LAT_5._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I55.MXPA1 _ADDLATA._RADD_LAT_5._BSTADD.I55.P1
+  RAA_P2[5] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I55.MXPOEN _ADDLATA.NET18[0] NCLKA
+  _ADDLATA._RADD_LAT_5._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I57.MXNA1 _ADDLATA._RADD_LAT_5._BSTADD.NSEL
+  ITEA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I57.MXPA1 _ADDLATA._RADD_LAT_5._BSTADD.NSEL
+  ITEA VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I62.MXNA1 RAYA5
+  _ADDLATA._RADD_LAT_5._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I62.MXPA1 RAYA5
+  _ADDLATA._RADD_LAT_5._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I63.MXNA1 _ADDLATA._RADD_LAT_5._BSTADD.IDY
+  _ADDLATA._RADD_LAT_5._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I63.MXPA1 _ADDLATA._RADD_LAT_5._BSTADD.IDY
+  _ADDLATA._RADD_LAT_5._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I65.MXNOE _ADDLATA.NET18[0] NCLKA
+  _ADDLATA._RADD_LAT_5._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_5._bstadd.I65.MXPOEN _ADDLATA.NET18[0] BCLKA
+  _ADDLATA._RADD_LAT_5._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXN1 _ADDLATA._RADD_LAT_5._BSTADD.ND TRAA5
+  _ADDLATA._RADD_LAT_5._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXN2 _ADDLATA._RADD_LAT_5._BSTADD.ND RAA5
+  _ADDLATA._RADD_LAT_5._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXN5 _ADDLATA._RADD_LAT_5._BSTADD.N1
+  _ADDLATA._RADD_LAT_5._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXN6 _ADDLATA._RADD_LAT_5._BSTADD.N2 ITEA VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXP1 _ADDLATA._RADD_LAT_5._BSTADD.ND RAA5
+  _ADDLATA._RADD_LAT_5._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXP3 _ADDLATA._RADD_LAT_5._BSTADD.ND TRAA5
+  _ADDLATA._RADD_LAT_5._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXP4 _ADDLATA._RADD_LAT_5._BSTADD.P1 ITEA
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlata._radd_lat_5._bstadd.MXP5 _ADDLATA._RADD_LAT_5._BSTADD.P2
+  _ADDLATA._RADD_LAT_5._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I0.MXNA1 _ADDLATB._CADD_LAT_0._BSTADD.NDY
+  _ADDLATB._CADD_LAT_0._BSTADD.IDY _ADDLATB._CADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I0.MXNA2 _ADDLATB._CADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I0.MXPA1 _ADDLATB._CADD_LAT_0._BSTADD.NDY
+  _ADDLATB._CADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I0.MXPA2 _ADDLATB._CADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I50.MXNA1 CAB_P2[0] _ADDLATB.NCA_P2[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I50.MXPA1 CAB_P2[0] _ADDLATB.NCA_P2[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I55.MXNA1 _ADDLATB._CADD_LAT_0._BSTADD.I55.N1
+  CAB_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I55.MXNOE _ADDLATB.NCA_P2[0] BCLKB
+  _ADDLATB._CADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I55.MXPA1 _ADDLATB._CADD_LAT_0._BSTADD.I55.P1
+  CAB_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I55.MXPOEN _ADDLATB.NCA_P2[0] NCLKB
+  _ADDLATB._CADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I57.MXNA1 _ADDLATB._CADD_LAT_0._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I57.MXPA1 _ADDLATB._CADD_LAT_0._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I62.MXNA1 CAYB0
+  _ADDLATB._CADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I62.MXPA1 CAYB0
+  _ADDLATB._CADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I63.MXNA1 _ADDLATB._CADD_LAT_0._BSTADD.IDY
+  _ADDLATB._CADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I63.MXPA1 _ADDLATB._CADD_LAT_0._BSTADD.IDY
+  _ADDLATB._CADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I65.MXNOE _ADDLATB.NCA_P2[0] NCLKB
+  _ADDLATB._CADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.I65.MXPOEN _ADDLATB.NCA_P2[0] BCLKB
+  _ADDLATB._CADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXN1 _ADDLATB._CADD_LAT_0._BSTADD.ND TCAB0
+  _ADDLATB._CADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXN2 _ADDLATB._CADD_LAT_0._BSTADD.ND CAB0
+  _ADDLATB._CADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXN5 _ADDLATB._CADD_LAT_0._BSTADD.N1
+  _ADDLATB._CADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXN6 _ADDLATB._CADD_LAT_0._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXP1 _ADDLATB._CADD_LAT_0._BSTADD.ND CAB0
+  _ADDLATB._CADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXP3 _ADDLATB._CADD_LAT_0._BSTADD.ND TCAB0
+  _ADDLATB._CADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXP4 _ADDLATB._CADD_LAT_0._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_0._bstadd.MXP5 _ADDLATB._CADD_LAT_0._BSTADD.P2
+  _ADDLATB._CADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I0.MXNA1 _ADDLATB._CADD_LAT_1._BSTADD.NDY
+  _ADDLATB._CADD_LAT_1._BSTADD.IDY _ADDLATB._CADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I0.MXNA2 _ADDLATB._CADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I0.MXPA1 _ADDLATB._CADD_LAT_1._BSTADD.NDY
+  _ADDLATB._CADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I0.MXPA2 _ADDLATB._CADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I50.MXNA1 CAB_P2[1] _ADDLATB.NCA_P2[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I50.MXPA1 CAB_P2[1] _ADDLATB.NCA_P2[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I55.MXNA1 _ADDLATB._CADD_LAT_1._BSTADD.I55.N1
+  CAB_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I55.MXNOE _ADDLATB.NCA_P2[1] BCLKB
+  _ADDLATB._CADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I55.MXPA1 _ADDLATB._CADD_LAT_1._BSTADD.I55.P1
+  CAB_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I55.MXPOEN _ADDLATB.NCA_P2[1] NCLKB
+  _ADDLATB._CADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I57.MXNA1 _ADDLATB._CADD_LAT_1._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I57.MXPA1 _ADDLATB._CADD_LAT_1._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I62.MXNA1 CAYB1
+  _ADDLATB._CADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I62.MXPA1 CAYB1
+  _ADDLATB._CADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I63.MXNA1 _ADDLATB._CADD_LAT_1._BSTADD.IDY
+  _ADDLATB._CADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I63.MXPA1 _ADDLATB._CADD_LAT_1._BSTADD.IDY
+  _ADDLATB._CADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I65.MXNOE _ADDLATB.NCA_P2[1] NCLKB
+  _ADDLATB._CADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.I65.MXPOEN _ADDLATB.NCA_P2[1] BCLKB
+  _ADDLATB._CADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXN1 _ADDLATB._CADD_LAT_1._BSTADD.ND TCAB1
+  _ADDLATB._CADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXN2 _ADDLATB._CADD_LAT_1._BSTADD.ND CAB1
+  _ADDLATB._CADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXN5 _ADDLATB._CADD_LAT_1._BSTADD.N1
+  _ADDLATB._CADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXN6 _ADDLATB._CADD_LAT_1._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXP1 _ADDLATB._CADD_LAT_1._BSTADD.ND CAB1
+  _ADDLATB._CADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXP3 _ADDLATB._CADD_LAT_1._BSTADD.ND TCAB1
+  _ADDLATB._CADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXP4 _ADDLATB._CADD_LAT_1._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._cadd_lat_1._bstadd.MXP5 _ADDLATB._CADD_LAT_1._BSTADD.P2
+  _ADDLATB._CADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I0.MXNA1 _ADDLATB._LADD_LAT_0._BSTADD.NDY
+  _ADDLATB._LADD_LAT_0._BSTADD.IDY _ADDLATB._LADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I0.MXNA2 _ADDLATB._LADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I0.MXPA1 _ADDLATB._LADD_LAT_0._BSTADD.NDY
+  _ADDLATB._LADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I0.MXPA2 _ADDLATB._LADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I50.MXNA1 LAB_P2[0] _ADDLATB.NET48[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I50.MXPA1 LAB_P2[0] _ADDLATB.NET48[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I55.MXNA1 _ADDLATB._LADD_LAT_0._BSTADD.I55.N1
+  LAB_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I55.MXNOE _ADDLATB.NET48[1] BCLKB
+  _ADDLATB._LADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I55.MXPA1 _ADDLATB._LADD_LAT_0._BSTADD.I55.P1
+  LAB_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I55.MXPOEN _ADDLATB.NET48[1] NCLKB
+  _ADDLATB._LADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I57.MXNA1 _ADDLATB._LADD_LAT_0._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I57.MXPA1 _ADDLATB._LADD_LAT_0._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I62.MXNA1 LAYB0
+  _ADDLATB._LADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I62.MXPA1 LAYB0
+  _ADDLATB._LADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I63.MXNA1 _ADDLATB._LADD_LAT_0._BSTADD.IDY
+  _ADDLATB._LADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I63.MXPA1 _ADDLATB._LADD_LAT_0._BSTADD.IDY
+  _ADDLATB._LADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I65.MXNOE _ADDLATB.NET48[1] NCLKB
+  _ADDLATB._LADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.I65.MXPOEN _ADDLATB.NET48[1] BCLKB
+  _ADDLATB._LADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXN1 _ADDLATB._LADD_LAT_0._BSTADD.ND TLAB0
+  _ADDLATB._LADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXN2 _ADDLATB._LADD_LAT_0._BSTADD.ND LAB0
+  _ADDLATB._LADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXN5 _ADDLATB._LADD_LAT_0._BSTADD.N1
+  _ADDLATB._LADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXN6 _ADDLATB._LADD_LAT_0._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXP1 _ADDLATB._LADD_LAT_0._BSTADD.ND LAB0
+  _ADDLATB._LADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXP3 _ADDLATB._LADD_LAT_0._BSTADD.ND TLAB0
+  _ADDLATB._LADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXP4 _ADDLATB._LADD_LAT_0._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_0._bstadd.MXP5 _ADDLATB._LADD_LAT_0._BSTADD.P2
+  _ADDLATB._LADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I0.MXNA1 _ADDLATB._LADD_LAT_1._BSTADD.NDY
+  _ADDLATB._LADD_LAT_1._BSTADD.IDY _ADDLATB._LADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I0.MXNA2 _ADDLATB._LADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I0.MXPA1 _ADDLATB._LADD_LAT_1._BSTADD.NDY
+  _ADDLATB._LADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I0.MXPA2 _ADDLATB._LADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I50.MXNA1 LAB_P2[1] _ADDLATB.NET48[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I50.MXPA1 LAB_P2[1] _ADDLATB.NET48[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I55.MXNA1 _ADDLATB._LADD_LAT_1._BSTADD.I55.N1
+  LAB_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I55.MXNOE _ADDLATB.NET48[0] BCLKB
+  _ADDLATB._LADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I55.MXPA1 _ADDLATB._LADD_LAT_1._BSTADD.I55.P1
+  LAB_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I55.MXPOEN _ADDLATB.NET48[0] NCLKB
+  _ADDLATB._LADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I57.MXNA1 _ADDLATB._LADD_LAT_1._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I57.MXPA1 _ADDLATB._LADD_LAT_1._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I62.MXNA1 LAYB1
+  _ADDLATB._LADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I62.MXPA1 LAYB1
+  _ADDLATB._LADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I63.MXNA1 _ADDLATB._LADD_LAT_1._BSTADD.IDY
+  _ADDLATB._LADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I63.MXPA1 _ADDLATB._LADD_LAT_1._BSTADD.IDY
+  _ADDLATB._LADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I65.MXNOE _ADDLATB.NET48[0] NCLKB
+  _ADDLATB._LADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.I65.MXPOEN _ADDLATB.NET48[0] BCLKB
+  _ADDLATB._LADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXN1 _ADDLATB._LADD_LAT_1._BSTADD.ND TLAB1
+  _ADDLATB._LADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXN2 _ADDLATB._LADD_LAT_1._BSTADD.ND LAB1
+  _ADDLATB._LADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXN5 _ADDLATB._LADD_LAT_1._BSTADD.N1
+  _ADDLATB._LADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXN6 _ADDLATB._LADD_LAT_1._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXP1 _ADDLATB._LADD_LAT_1._BSTADD.ND LAB1
+  _ADDLATB._LADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXP3 _ADDLATB._LADD_LAT_1._BSTADD.ND TLAB1
+  _ADDLATB._LADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXP4 _ADDLATB._LADD_LAT_1._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._ladd_lat_1._bstadd.MXP5 _ADDLATB._LADD_LAT_1._BSTADD.P2
+  _ADDLATB._LADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_0._BSTADD.NDY
+  _ADDLATB._RADD_LAT_0._BSTADD.IDY _ADDLATB._RADD_LAT_0._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_0._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_0._BSTADD.NDY
+  _ADDLATB._RADD_LAT_0._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_0._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I50.MXNA1 RAB_P2[0] _ADDLATB.NET27[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I50.MXPA1 RAB_P2[0] _ADDLATB.NET27[2] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_0._BSTADD.I55.N1
+  RAB_P2[0] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I55.MXNOE _ADDLATB.NET27[2] BCLKB
+  _ADDLATB._RADD_LAT_0._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_0._BSTADD.I55.P1
+  RAB_P2[0] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I55.MXPOEN _ADDLATB.NET27[2] NCLKB
+  _ADDLATB._RADD_LAT_0._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_0._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_0._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I62.MXNA1 RAYB0
+  _ADDLATB._RADD_LAT_0._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I62.MXPA1 RAYB0
+  _ADDLATB._RADD_LAT_0._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_0._BSTADD.IDY
+  _ADDLATB._RADD_LAT_0._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_0._BSTADD.IDY
+  _ADDLATB._RADD_LAT_0._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I65.MXNOE _ADDLATB.NET27[2] NCLKB
+  _ADDLATB._RADD_LAT_0._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.I65.MXPOEN _ADDLATB.NET27[2] BCLKB
+  _ADDLATB._RADD_LAT_0._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXN1 _ADDLATB._RADD_LAT_0._BSTADD.ND TRAB0
+  _ADDLATB._RADD_LAT_0._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXN2 _ADDLATB._RADD_LAT_0._BSTADD.ND RAB0
+  _ADDLATB._RADD_LAT_0._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXN5 _ADDLATB._RADD_LAT_0._BSTADD.N1
+  _ADDLATB._RADD_LAT_0._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXN6 _ADDLATB._RADD_LAT_0._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXP1 _ADDLATB._RADD_LAT_0._BSTADD.ND RAB0
+  _ADDLATB._RADD_LAT_0._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXP3 _ADDLATB._RADD_LAT_0._BSTADD.ND TRAB0
+  _ADDLATB._RADD_LAT_0._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXP4 _ADDLATB._RADD_LAT_0._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_0._bstadd.MXP5 _ADDLATB._RADD_LAT_0._BSTADD.P2
+  _ADDLATB._RADD_LAT_0._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_1._BSTADD.NDY
+  _ADDLATB._RADD_LAT_1._BSTADD.IDY _ADDLATB._RADD_LAT_1._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_1._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_1._BSTADD.NDY
+  _ADDLATB._RADD_LAT_1._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_1._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I50.MXNA1 RAB_P2[1] _ADDLATB.NET27[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I50.MXPA1 RAB_P2[1] _ADDLATB.NET27[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_1._BSTADD.I55.N1
+  RAB_P2[1] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I55.MXNOE _ADDLATB.NET27[1] BCLKB
+  _ADDLATB._RADD_LAT_1._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_1._BSTADD.I55.P1
+  RAB_P2[1] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I55.MXPOEN _ADDLATB.NET27[1] NCLKB
+  _ADDLATB._RADD_LAT_1._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_1._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_1._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I62.MXNA1 RAYB1
+  _ADDLATB._RADD_LAT_1._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I62.MXPA1 RAYB1
+  _ADDLATB._RADD_LAT_1._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_1._BSTADD.IDY
+  _ADDLATB._RADD_LAT_1._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_1._BSTADD.IDY
+  _ADDLATB._RADD_LAT_1._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I65.MXNOE _ADDLATB.NET27[1] NCLKB
+  _ADDLATB._RADD_LAT_1._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.I65.MXPOEN _ADDLATB.NET27[1] BCLKB
+  _ADDLATB._RADD_LAT_1._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXN1 _ADDLATB._RADD_LAT_1._BSTADD.ND TRAB1
+  _ADDLATB._RADD_LAT_1._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXN2 _ADDLATB._RADD_LAT_1._BSTADD.ND RAB1
+  _ADDLATB._RADD_LAT_1._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXN5 _ADDLATB._RADD_LAT_1._BSTADD.N1
+  _ADDLATB._RADD_LAT_1._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXN6 _ADDLATB._RADD_LAT_1._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXP1 _ADDLATB._RADD_LAT_1._BSTADD.ND RAB1
+  _ADDLATB._RADD_LAT_1._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXP3 _ADDLATB._RADD_LAT_1._BSTADD.ND TRAB1
+  _ADDLATB._RADD_LAT_1._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXP4 _ADDLATB._RADD_LAT_1._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_1._bstadd.MXP5 _ADDLATB._RADD_LAT_1._BSTADD.P2
+  _ADDLATB._RADD_LAT_1._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_2._BSTADD.NDY
+  _ADDLATB._RADD_LAT_2._BSTADD.IDY _ADDLATB._RADD_LAT_2._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_2._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_2._BSTADD.NDY
+  _ADDLATB._RADD_LAT_2._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_2._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I50.MXNA1 RAB_P2[2] _ADDLATB.NET27[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I50.MXPA1 RAB_P2[2] _ADDLATB.NET27[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_2._BSTADD.I55.N1
+  RAB_P2[2] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I55.MXNOE _ADDLATB.NET27[0] BCLKB
+  _ADDLATB._RADD_LAT_2._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_2._BSTADD.I55.P1
+  RAB_P2[2] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I55.MXPOEN _ADDLATB.NET27[0] NCLKB
+  _ADDLATB._RADD_LAT_2._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_2._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_2._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I62.MXNA1 RAYB2
+  _ADDLATB._RADD_LAT_2._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I62.MXPA1 RAYB2
+  _ADDLATB._RADD_LAT_2._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_2._BSTADD.IDY
+  _ADDLATB._RADD_LAT_2._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_2._BSTADD.IDY
+  _ADDLATB._RADD_LAT_2._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I65.MXNOE _ADDLATB.NET27[0] NCLKB
+  _ADDLATB._RADD_LAT_2._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.I65.MXPOEN _ADDLATB.NET27[0] BCLKB
+  _ADDLATB._RADD_LAT_2._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXN1 _ADDLATB._RADD_LAT_2._BSTADD.ND TRAB2
+  _ADDLATB._RADD_LAT_2._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXN2 _ADDLATB._RADD_LAT_2._BSTADD.ND RAB2
+  _ADDLATB._RADD_LAT_2._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXN5 _ADDLATB._RADD_LAT_2._BSTADD.N1
+  _ADDLATB._RADD_LAT_2._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXN6 _ADDLATB._RADD_LAT_2._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXP1 _ADDLATB._RADD_LAT_2._BSTADD.ND RAB2
+  _ADDLATB._RADD_LAT_2._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXP3 _ADDLATB._RADD_LAT_2._BSTADD.ND TRAB2
+  _ADDLATB._RADD_LAT_2._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXP4 _ADDLATB._RADD_LAT_2._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_2._bstadd.MXP5 _ADDLATB._RADD_LAT_2._BSTADD.P2
+  _ADDLATB._RADD_LAT_2._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_3._BSTADD.NDY
+  _ADDLATB._RADD_LAT_3._BSTADD.IDY _ADDLATB._RADD_LAT_3._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_3._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_3._BSTADD.NDY
+  _ADDLATB._RADD_LAT_3._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_3._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I50.MXNA1 RAB_P2[3] _ADDLATB.NET18[2] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I50.MXPA1 RAB_P2[3] _ADDLATB.NET18[2] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_3._BSTADD.I55.N1
+  RAB_P2[3] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I55.MXNOE _ADDLATB.NET18[2] BCLKB
+  _ADDLATB._RADD_LAT_3._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_3._BSTADD.I55.P1
+  RAB_P2[3] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I55.MXPOEN _ADDLATB.NET18[2] NCLKB
+  _ADDLATB._RADD_LAT_3._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_3._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_3._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I62.MXNA1 RAYB3
+  _ADDLATB._RADD_LAT_3._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I62.MXPA1 RAYB3
+  _ADDLATB._RADD_LAT_3._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_3._BSTADD.IDY
+  _ADDLATB._RADD_LAT_3._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_3._BSTADD.IDY
+  _ADDLATB._RADD_LAT_3._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I65.MXNOE _ADDLATB.NET18[2] NCLKB
+  _ADDLATB._RADD_LAT_3._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.I65.MXPOEN _ADDLATB.NET18[2] BCLKB
+  _ADDLATB._RADD_LAT_3._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXN1 _ADDLATB._RADD_LAT_3._BSTADD.ND TRAB3
+  _ADDLATB._RADD_LAT_3._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXN2 _ADDLATB._RADD_LAT_3._BSTADD.ND RAB3
+  _ADDLATB._RADD_LAT_3._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXN5 _ADDLATB._RADD_LAT_3._BSTADD.N1
+  _ADDLATB._RADD_LAT_3._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXN6 _ADDLATB._RADD_LAT_3._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXP1 _ADDLATB._RADD_LAT_3._BSTADD.ND RAB3
+  _ADDLATB._RADD_LAT_3._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXP3 _ADDLATB._RADD_LAT_3._BSTADD.ND TRAB3
+  _ADDLATB._RADD_LAT_3._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXP4 _ADDLATB._RADD_LAT_3._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_3._bstadd.MXP5 _ADDLATB._RADD_LAT_3._BSTADD.P2
+  _ADDLATB._RADD_LAT_3._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_4._BSTADD.NDY
+  _ADDLATB._RADD_LAT_4._BSTADD.IDY _ADDLATB._RADD_LAT_4._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_4._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_4._BSTADD.NDY
+  _ADDLATB._RADD_LAT_4._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_4._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I50.MXNA1 RAB_P2[4] _ADDLATB.NET18[1] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I50.MXPA1 RAB_P2[4] _ADDLATB.NET18[1] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_4._BSTADD.I55.N1
+  RAB_P2[4] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I55.MXNOE _ADDLATB.NET18[1] BCLKB
+  _ADDLATB._RADD_LAT_4._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_4._BSTADD.I55.P1
+  RAB_P2[4] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I55.MXPOEN _ADDLATB.NET18[1] NCLKB
+  _ADDLATB._RADD_LAT_4._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_4._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_4._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I62.MXNA1 RAYB4
+  _ADDLATB._RADD_LAT_4._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I62.MXPA1 RAYB4
+  _ADDLATB._RADD_LAT_4._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_4._BSTADD.IDY
+  _ADDLATB._RADD_LAT_4._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_4._BSTADD.IDY
+  _ADDLATB._RADD_LAT_4._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I65.MXNOE _ADDLATB.NET18[1] NCLKB
+  _ADDLATB._RADD_LAT_4._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.I65.MXPOEN _ADDLATB.NET18[1] BCLKB
+  _ADDLATB._RADD_LAT_4._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXN1 _ADDLATB._RADD_LAT_4._BSTADD.ND TRAB4
+  _ADDLATB._RADD_LAT_4._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXN2 _ADDLATB._RADD_LAT_4._BSTADD.ND RAB4
+  _ADDLATB._RADD_LAT_4._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXN5 _ADDLATB._RADD_LAT_4._BSTADD.N1
+  _ADDLATB._RADD_LAT_4._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXN6 _ADDLATB._RADD_LAT_4._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXP1 _ADDLATB._RADD_LAT_4._BSTADD.ND RAB4
+  _ADDLATB._RADD_LAT_4._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXP3 _ADDLATB._RADD_LAT_4._BSTADD.ND TRAB4
+  _ADDLATB._RADD_LAT_4._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXP4 _ADDLATB._RADD_LAT_4._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_4._bstadd.MXP5 _ADDLATB._RADD_LAT_4._BSTADD.P2
+  _ADDLATB._RADD_LAT_4._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I0.MXNA1 _ADDLATB._RADD_LAT_5._BSTADD.NDY
+  _ADDLATB._RADD_LAT_5._BSTADD.IDY _ADDLATB._RADD_LAT_5._BSTADD.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I0.MXNA2 _ADDLATB._RADD_LAT_5._BSTADD.I0.N1
+  IDFT VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I0.MXPA1 _ADDLATB._RADD_LAT_5._BSTADD.NDY
+  _ADDLATB._RADD_LAT_5._BSTADD.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I0.MXPA2 _ADDLATB._RADD_LAT_5._BSTADD.NDY IDFT
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I50.MXNA1 RAB_P2[5] _ADDLATB.NET18[0] VSS VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I50.MXPA1 RAB_P2[5] _ADDLATB.NET18[0] VDDPE
+  VNWP P11LL_CKT W=1.28U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I55.MXNA1 _ADDLATB._RADD_LAT_5._BSTADD.I55.N1
+  RAB_P2[5] VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I55.MXNOE _ADDLATB.NET18[0] BCLKB
+  _ADDLATB._RADD_LAT_5._BSTADD.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I55.MXPA1 _ADDLATB._RADD_LAT_5._BSTADD.I55.P1
+  RAB_P2[5] VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I55.MXPOEN _ADDLATB.NET18[0] NCLKB
+  _ADDLATB._RADD_LAT_5._BSTADD.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I57.MXNA1 _ADDLATB._RADD_LAT_5._BSTADD.NSEL
+  ITEB VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I57.MXPA1 _ADDLATB._RADD_LAT_5._BSTADD.NSEL
+  ITEB VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I62.MXNA1 RAYB5
+  _ADDLATB._RADD_LAT_5._BSTADD.NDY VSS VPW N11LL_CKT W=0.57U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I62.MXPA1 RAYB5
+  _ADDLATB._RADD_LAT_5._BSTADD.NDY VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I63.MXNA1 _ADDLATB._RADD_LAT_5._BSTADD.IDY
+  _ADDLATB._RADD_LAT_5._BSTADD.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I63.MXPA1 _ADDLATB._RADD_LAT_5._BSTADD.IDY
+  _ADDLATB._RADD_LAT_5._BSTADD.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I65.MXNOE _ADDLATB.NET18[0] NCLKB
+  _ADDLATB._RADD_LAT_5._BSTADD.ND VPW N11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.I65.MXPOEN _ADDLATB.NET18[0] BCLKB
+  _ADDLATB._RADD_LAT_5._BSTADD.ND VNWP P11LL_CKT W=0.425U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXN1 _ADDLATB._RADD_LAT_5._BSTADD.ND TRAB5
+  _ADDLATB._RADD_LAT_5._BSTADD.N2 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXN2 _ADDLATB._RADD_LAT_5._BSTADD.ND RAB5
+  _ADDLATB._RADD_LAT_5._BSTADD.N1 VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXN5 _ADDLATB._RADD_LAT_5._BSTADD.N1
+  _ADDLATB._RADD_LAT_5._BSTADD.NSEL VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXN6 _ADDLATB._RADD_LAT_5._BSTADD.N2 ITEB VSS
+  VPW N11LL_CKT W=0.34U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXP1 _ADDLATB._RADD_LAT_5._BSTADD.ND RAB5
+  _ADDLATB._RADD_LAT_5._BSTADD.P1 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXP3 _ADDLATB._RADD_LAT_5._BSTADD.ND TRAB5
+  _ADDLATB._RADD_LAT_5._BSTADD.P2 VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXP4 _ADDLATB._RADD_LAT_5._BSTADD.P1 ITEB
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_addlatb._radd_lat_5._bstadd.MXP5 _ADDLATB._RADD_LAT_5._BSTADD.P2
+  _ADDLATB._RADD_LAT_5._BSTADD.NSEL VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_cka.I138.MXNA1 RET RET1N _CKA.I138.N1 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXNA2 _CKA.I138.N1 TIEHIA VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXPA1 RET RET1N VDDCE VNWC P11LL_CKT W=1.135U L=0.04U
X_M_cka.I138.MXPA2 RET TIEHIA VDDCE VNWC P11LL_CKT W=0.565U L=0.04U
X_M_cka.I239_0.MXNA1 _CKA.NCAA_P2[0] CAA_P2[0] VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_cka.I239_0.MXPA1 _CKA.NCAA_P2[0] CAA_P2[0] VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka.I239_1.MXNA1 _CKA.NCAA_P2[1] CAA_P2[1] VSS VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_cka.I239_1.MXPA1 _CKA.NCAA_P2[1] CAA_P2[1] VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka.I241.MXNA1 _CKA.NET109 _CKA.GTPA_SA VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I241.MXNA2 _CKA.NET109 _CKA.GTPA_SA_DLY VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka.I241.MXPA1 _CKA.NET109 _CKA.GTPA_SA _CKA.I241.P1 VNWP P11LL_CKT
+  W=0.85U L=0.04U
X_M_cka.I241.MXPA2 _CKA.I241.P1 _CKA.GTPA_SA_DLY VDDPE VNWP P11LL_CKT W=0.774U
+  L=0.04U
X_M_cka.I242.MXNA1 _CKA.I242.N1 _CKA.NET0125 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I242.MXNOE _CKA.NET0119 _CKA.NET0125 _CKA.I242.N1 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I242.MXPA1 _CKA.I242.P1 _CKA.NET0125 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I242.MXPOEN _CKA.NET0119 _CKA.NET0125 _CKA.I242.P1 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I244_0.MXNA1 _CKA.ICAA_P2[0] _CKA.NCAA_P2[0] VSS VPW N11LL_CKT W=0.26U
+  L=0.04U
X_M_cka.I244_0.MXPA1 _CKA.ICAA_P2[0] _CKA.NCAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.485U L=0.04U
X_M_cka.I244_1.MXNA1 _CKA.ICAA_P2[1] _CKA.NCAA_P2[1] VSS VPW N11LL_CKT W=0.26U
+  L=0.04U
X_M_cka.I244_1.MXPA1 _CKA.ICAA_P2[1] _CKA.NCAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.485U L=0.04U
X_M_cka.I245.MXNA1 _CKA.NDFTNRETA RET VSSE VPW N11LL_CKT W=0.655U L=0.04U
X_M_cka.I245.MXNA2 _CKA.NDFTNRETA IDFTA_P2 VSSE VPW N11LL_CKT W=0.655U L=0.04U
X_M_cka.I245.MXPA1 _CKA.NDFTNRETA RET _CKA.I245.P1 VNWC P11LL_CKT W=1.845U
+  L=0.04U
X_M_cka.I245.MXPA2 _CKA.I245.P1 IDFTA_P2 VDDCE VNWC P11LL_CKT W=1.845U L=0.04U
X_M_cka.I246.MXNA1 _CKA.NET0125 RET VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I246.MXNA2 _CKA.NET0125 GTPA VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I246.MXPA1 _CKA.NET0125 RET _CKA.I246.P1 VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I246.MXPA2 _CKA.I246.P1 GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I252.MXN3 _CKA.I252.NET50 _CKA.I252.NDI VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXN4 _CKA.I252.NDI _CKA.GTPA_SA VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka.I252.MXN8 _CKA.GTPA_SA_DLY _CKA.I252.NDI _CKA.I252.NET50 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka.I252.MXP0 _CKA.GTPA_SA_DLY _CKA.I252.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXP1 _CKA.I252.NDI _CKA.GTPA_SA VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_cka.I252.MXP2 VDDPE _CKA.GTPA_SA VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_cka.I32.MXNA1 NCLKA GTPA VSSE VPW N11LL_CKT W=1.275U L=0.04U
X_M_cka.I32.MXPA1 NCLKA GTPA VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cka.I4.MXNA1 _CKA.NICLK GTPA VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I4.MXPA1 _CKA.NICLK GTPA VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_M_cka.I5.MXNA1 BCLKA _CKA.NICLK VSSE VPW N11LL_CKT W=1.275U L=0.04U
X_M_cka.I5.MXPA1 BCLKA _CKA.NICLK VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cka.I51.MXNA1 _CKA.NGTPA GTPA VSS VPW N11LL_CKT W=0.91U L=0.04U
X_M_cka.I51.MXPA1 _CKA.NGTPA GTPA VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_cka.I52.MXNA1 DFTRETA _CKA.NDFTNRETA VSSE VPW N11LL_CKT W=3.7U L=0.04U
X_M_cka.I52.MXPA1 DFTRETA _CKA.NDFTNRETA VDDCE VNWC P11LL_CKT W=5.54U L=0.04U
X_M_cka.I60.MXNA1 NSAE _CKA.NET204 VSS VPW N11LL_CKT W=7.94U L=0.04U
X_M_cka.I60.MXPA1 NSAE _CKA.NET204 VDDPE VNWP P11LL_CKT W=7.1U L=0.04U
X_M_cka.I61.MXNA1 SAPRECH _CKA.NSAPRECH VSSE VPW N11LL_CKT W=5.68U L=0.04U
X_M_cka.I61.MXPA1 SAPRECH _CKA.NSAPRECH VDDPE VNWP P11LL_CKT W=4U L=0.04U
X_M_cka.I64.MXNA1 _CKA.NSAPRECH _CKA.ISAPRECH VSSE VPW N11LL_CKT W=0.5U
+  L=0.04U
X_M_cka.I64.MXPA1 _CKA.NSAPRECH _CKA.ISAPRECH VDDPE VNWP P11LL_CKT W=2.02U
+  L=0.04U
X_M_cka.I7.MXNA1 _CKA.DFTCLKA NCLKA VSSE VPW N11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXNA2 _CKA.DFTCLKA IDFTA_P2 VSSE VPW N11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXPA1 _CKA.DFTCLKA NCLKA _CKA.I7.P1 VNWP P11LL_CKT W=0.905U L=0.04U
X_M_cka.I7.MXPA2 _CKA.I7.P1 IDFTA_P2 VDDPE VNWP P11LL_CKT W=0.905U L=0.04U
X_M_cka.I77.MXNA1 _CKA.ISAPRECH _CKA.NET0119 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka.I77.MXNA2 _CKA.ISAPRECH GTPA VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka.I77.MXPA1 _CKA.ISAPRECH _CKA.NET0119 _CKA.I77.P1 VNWP P11LL_CKT W=0.5U
+  L=0.04U
X_M_cka.I77.MXPA2 _CKA.I77.P1 GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_cka.I80.MXNA1 _CKA.NET204 _CKA.NET109 VSS VPW N11LL_CKT W=0.868U L=0.04U
X_M_cka.I80.MXPA1 _CKA.NET204 _CKA.NET109 VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_M_cka.MXN0 TIELOCDA TIEHIA VSSE VPW N11LL_CKT W=2.27U L=0.04U
X_M_cka.MXN1 TIELOFPA TIEHIA VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_cka.RF2YDec2to4a.I16_0.MXNA1 NYPACLK[0] _CKA.RF2YDEC2TO4A.NET37[3] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_0.MXPA1 NYPACLK[0] _CKA.RF2YDEC2TO4A.NET37[3] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_1.MXNA1 NYPACLK[1] _CKA.RF2YDEC2TO4A.NET37[2] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_1.MXPA1 NYPACLK[1] _CKA.RF2YDEC2TO4A.NET37[2] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_2.MXNA1 NYPACLK[2] _CKA.RF2YDEC2TO4A.NET37[1] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_2.MXPA1 NYPACLK[2] _CKA.RF2YDEC2TO4A.NET37[1] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I16_3.MXNA1 NYPACLK[3] _CKA.RF2YDEC2TO4A.NET37[0] VSS VPW
+  N11LL_CKT W=5.1U L=0.04U
X_M_cka.RF2YDec2to4a.I16_3.MXPA1 NYPACLK[3] _CKA.RF2YDEC2TO4A.NET37[0] VDDPE
+  VNWP P11LL_CKT W=7.66U L=0.04U
X_M_cka.RF2YDec2to4a.I17_0.MXNA1 _CKA.RF2YDEC2TO4A.NET37[3]
+  _CKA.RF2YDEC2TO4A.NET17[3] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_0.MXPA1 _CKA.RF2YDEC2TO4A.NET37[3]
+  _CKA.RF2YDEC2TO4A.NET17[3] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_1.MXNA1 _CKA.RF2YDEC2TO4A.NET37[2]
+  _CKA.RF2YDEC2TO4A.NET17[2] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_1.MXPA1 _CKA.RF2YDEC2TO4A.NET37[2]
+  _CKA.RF2YDEC2TO4A.NET17[2] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_2.MXNA1 _CKA.RF2YDEC2TO4A.NET37[1]
+  _CKA.RF2YDEC2TO4A.NET17[1] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_2.MXPA1 _CKA.RF2YDEC2TO4A.NET37[1]
+  _CKA.RF2YDEC2TO4A.NET17[1] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_3.MXNA1 _CKA.RF2YDEC2TO4A.NET37[0]
+  _CKA.RF2YDEC2TO4A.NET17[0] VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_M_cka.RF2YDec2to4a.I17_3.MXPA1 _CKA.RF2YDEC2TO4A.NET37[0]
+  _CKA.RF2YDEC2TO4A.NET17[0] VDDPE VNWP P11LL_CKT W=2.42U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[0] _CKA.ICAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_0.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_0.MXPA2 _CKA.RF2YDEC2TO4A.I8_0.P1 _CKA.ICAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.ICAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.NCAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[1] _CKA.ICAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_1.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_1.MXPA2 _CKA.RF2YDEC2TO4A.I8_1.P1 _CKA.NCAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.NCAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.ICAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[2] _CKA.NCAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_2.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_2.MXPA2 _CKA.RF2YDEC2TO4A.I8_2.P1 _CKA.ICAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXNA1 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[1] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXNA2 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[0] VSS
+  VPW N11LL_CKT W=0.2U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXPA1 _CKA.RF2YDEC2TO4A.IDEC[3] _CKA.NCAA_P2[1]
+  _CKA.RF2YDEC2TO4A.I8_3.P1 VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I8_3.MXPA2 _CKA.RF2YDEC2TO4A.I8_3.P1 _CKA.NCAA_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.395U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXN0 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_0.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXN1 _CKA.RF2YDEC2TO4A.I9_0.N2
+  _CKA.RF2YDEC2TO4A.IDEC[0] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXNA1 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_0.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXNA2 _CKA.RF2YDEC2TO4A.I9_0.N1
+  _CKA.RF2YDEC2TO4A.IDEC[0] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXPA1 _CKA.RF2YDEC2TO4A.NET17[3] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_0.MXPA2 _CKA.RF2YDEC2TO4A.NET17[3]
+  _CKA.RF2YDEC2TO4A.IDEC[0] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXN0 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_1.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXN1 _CKA.RF2YDEC2TO4A.I9_1.N2
+  _CKA.RF2YDEC2TO4A.IDEC[1] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXNA1 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_1.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXNA2 _CKA.RF2YDEC2TO4A.I9_1.N1
+  _CKA.RF2YDEC2TO4A.IDEC[1] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXPA1 _CKA.RF2YDEC2TO4A.NET17[2] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_1.MXPA2 _CKA.RF2YDEC2TO4A.NET17[2]
+  _CKA.RF2YDEC2TO4A.IDEC[1] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXN0 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_2.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXN1 _CKA.RF2YDEC2TO4A.I9_2.N2
+  _CKA.RF2YDEC2TO4A.IDEC[2] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXNA1 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_2.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXNA2 _CKA.RF2YDEC2TO4A.I9_2.N1
+  _CKA.RF2YDEC2TO4A.IDEC[2] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXPA1 _CKA.RF2YDEC2TO4A.NET17[1] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_2.MXPA2 _CKA.RF2YDEC2TO4A.NET17[1]
+  _CKA.RF2YDEC2TO4A.IDEC[2] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXN0 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_3.N2 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXN1 _CKA.RF2YDEC2TO4A.I9_3.N2
+  _CKA.RF2YDEC2TO4A.IDEC[3] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXNA1 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA
+  _CKA.RF2YDEC2TO4A.I9_3.N1 VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXNA2 _CKA.RF2YDEC2TO4A.I9_3.N1
+  _CKA.RF2YDEC2TO4A.IDEC[3] VSS VPW N11LL_CKT W=0.33U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXPA1 _CKA.RF2YDEC2TO4A.NET17[0] _CKA.DFTCLKA VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka.RF2YDec2to4a.I9_3.MXPA2 _CKA.RF2YDEC2TO4A.NET17[0]
+  _CKA.RF2YDEC2TO4A.IDEC[3] VDDPE VNWP P11LL_CKT W=0.52U L=0.04U
X_M_cka._clk.I222.MXNA1 _CKA._CLK.GTPRST _CKA.GTPA_SA VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_cka._clk.I222.MXPA1 _CKA._CLK.GTPRST _CKA.GTPA_SA VDDPE VNWP P11LL_CKT
+  W=0.71U L=0.04U
X_M_cka._clk.I5.MXNA1 _CKA._CLK.NRET RET VSSE VPW N11LL_CKT W=0.16U L=0.04U
X_M_cka._clk.I5.MXPA1 _CKA._CLK.NRET RET VDDPE VNWP P11LL_CKT W=0.155U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.I68.MXNA1 _CKA._CLK.SAE_DUMMY DBLA VSSE VPW
+  N11LL_CKT W=1.14U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.I68.MXPA1 _CKA._CLK.SAE_DUMMY DBLA VDDPE VNWP
+  P11LL_CKT W=2.265U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXN0 VSSE DBLA VSSE VPW N11LL_CKT W=2.39U L=0.085U
X_M_cka._clk._cdm2_dummy_hd.MXN1 VSS DBLA VSS VPW N11LL_CKT W=0.285U L=0.085U
X_M_cka._clk._cdm2_dummy_hd.MXN4_0 DBLA TIELODBLA DBLA VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXN4_1 DBLA TIELODBLA DBLA VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP1_0 DBLA TIELODBLA DBLA VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP1_1 DBLA TIELODBLA DBLA VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP2 VDDPE DBLA VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXP3 VDDPE DBLA VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXPPU1_0 DBLA TIELODBLA DBLA VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_cka._clk._cdm2_dummy_hd.MXPPU1_1 DBLA TIELODBLA DBLA VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd.I61.MXNA1 _CKA._CLK.NET61 _CKA._CLK.SAE_DUMMY
+  VSSE VPW N11LL_CKT W=1.03U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd.I61.MXPA1 _CKA._CLK.NET61 _CKA._CLK.SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=1.53U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET40 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET045 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKMX1O _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET40 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET045 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly0.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY0.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET046 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKDLY2 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET046
+  VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET038 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD.CKDLY2 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly1.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY1.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN3
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET046 _CKA._CLK.SAE_DUMMY
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN8 _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK.SAE_DUMMY _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET046 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXN9
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET038 _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP0 _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK.SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET030
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rdly2.MXP4 _CKA._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKA._CLK._CK_RD_EMA47_HD._RDLY2.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I12.N1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I12.MXPA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 EMAA0 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKA._CLK._CK_RD_EMA47_HD.CKDLY0 VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I13.MXPA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1 EMAA0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNA1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2 _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXNB1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK.NET61 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPA1 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A0
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPA2 _CKA._CLK._CK_RD_EMA47_HD.NET67
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.A1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I18.MXPB1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP _CKA._CLK.NET61 VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAA0 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx0.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAA0 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I19.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I19.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN _CKA._CLK.SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=0.45U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAA2 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAA2 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I20.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.NET67
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I20.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.NET67
+  VDDPE VNWP P11LL_CKT W=0.45U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I21.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VPW N11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I21.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I22.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAA2
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VPW N11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I22.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I23.MXNA1 _CKA.GTPA_SA
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx00.I23.MXPA1 _CKA.GTPA_SA
+  _CKA._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I19.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN _CKA._CLK.SAE_DUMMY VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I19.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN _CKA._CLK.SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I2.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAA1 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I2.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAA1 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I20.MXNA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I20.MXPA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKA._CLK._CK_RD_EMA47_HD.CKDLY1
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I21.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I21.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I22.MXNOE
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAA1
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I22.MXPOEN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I23.MXNA1 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._ck_rd_ema47_hd._rmx1.I23.MXPA1 _CKA._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKA._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_cka._clk._dwd.MXNA1 DWLA _CKA._CLK.NGTP VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_cka._clk._dwd.MXPA1 DWLA _CKA._CLK.NGTP VDDP_DWLA VNWP P11LL_CKT W=5.67U
+  L=0.04U
X_M_cka._clk._mem_gtp.I1.MXNA1 _CKA._CLK._MEM_GTP.C1 _CKA._CLK._MEM_GTP.NCLK
+  _CKA._CLK._MEM_GTP.I1.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXNA2 _CKA._CLK._MEM_GTP.I1.N1 _CKA._CLK.NRET VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXPA1 _CKA._CLK._MEM_GTP.C1 _CKA._CLK._MEM_GTP.NCLK
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I1.MXPA2 _CKA._CLK._MEM_GTP.C1 _CKA._CLK.NRET VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNA1 _CKA._CLK._MEM_GTP.C2 BCENA
+  _CKA._CLK._MEM_GTP.I24.A1A2 VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNA2 _CKA._CLK._MEM_GTP.I24.A1A2
+  _CKA._CLK._MEM_GTP.NDFT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXNB1 _CKA._CLK._MEM_GTP.C2 _CKA._CLK._MEM_GTP.C1
+  VSSE VPW N11LL_CKT W=0.24U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPA1 _CKA._CLK._MEM_GTP.C2 BCENA
+  _CKA._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPA2 _CKA._CLK._MEM_GTP.C2 _CKA._CLK._MEM_GTP.NDFT
+  _CKA._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I24.MXPB1 _CKA._CLK._MEM_GTP.I24.A1A2UP
+  _CKA._CLK._MEM_GTP.C1 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cka._clk._mem_gtp.I6.MXNA1 GTPA _CKA._CLK.NGTP VSSE VPW N11LL_CKT W=5.61U
+  L=0.04U
X_M_cka._clk._mem_gtp.I6.MXPA1 GTPA _CKA._CLK.NGTP VDDPE VNWP P11LL_CKT
+  W=11.32U L=0.04U
X_M_cka._clk._mem_gtp.I68.MXNA1 _CKA._CLK._MEM_GTP.FEED _CKA._CLK.NGTP VSSE
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_cka._clk._mem_gtp.I68.MXPA1 _CKA._CLK._MEM_GTP.FEED _CKA._CLK.NGTP VDDPE
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_M_cka._clk._mem_gtp.I7.MXNA1 _CKA._CLK._MEM_GTP.NCLK CLKA VSS VPW N11LL_CKT
+  W=4.24U L=0.04U
X_M_cka._clk._mem_gtp.I7.MXPA1 _CKA._CLK._MEM_GTP.NCLK CLKA VDDPE VNWP
+  P11LL_CKT W=4.24U L=0.04U
X_M_cka._clk._mem_gtp.I74.MXNA1 _CKA._CLK.NFEED _CKA._CLK._MEM_GTP.FEED VSSE
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_cka._clk._mem_gtp.I74.MXPA1 _CKA._CLK.NFEED _CKA._CLK._MEM_GTP.FEED VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._clk._mem_gtp.I82.MXNA1 _CKA._CLK._MEM_GTP.CTR _CKA._CLK._MEM_GTP.C3
+  VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_M_cka._clk._mem_gtp.I82.MXPA1 _CKA._CLK._MEM_GTP.CTR _CKA._CLK._MEM_GTP.C3
+  VDDPE VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXNA1 _CKA._CLK._MEM_GTP.C3 _CKA._CLK._MEM_GTP.C2
+  _CKA._CLK._MEM_GTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXNA2 _CKA._CLK._MEM_GTP.I83.N1 _CKA._CLK.NFEED VSSE
+  VPW N11LL_CKT W=0.71U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXPA1 _CKA._CLK._MEM_GTP.C3 _CKA._CLK._MEM_GTP.C2
+  VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_M_cka._clk._mem_gtp.I83.MXPA2 _CKA._CLK._MEM_GTP.C3 _CKA._CLK.NFEED VDDPE
+  VNWP P11LL_CKT W=0.36U L=0.04U
X_M_cka._clk._mem_gtp.I86.MXNA1 _CKA._CLK._MEM_GTP.NDFT IDFTA_P2 VSS VPW
+  N11LL_CKT W=0.21U L=0.04U
X_M_cka._clk._mem_gtp.I86.MXPA1 _CKA._CLK._MEM_GTP.NDFT IDFTA_P2 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._clk._mem_gtp.MXN0 _CKA._CLK._MEM_GTP.NCLK _CKA._CLK._MEM_GTP.CTR
+  _CKA._CLK.NGTP VPW N11LL_CKT W=4.26U L=0.04U
X_M_cka._clk._mem_gtp.MXN7 _CKA._CLK.NGTP _CKA._CLK._MEM_GTP.FEED
+  _CKA._CLK._MEM_GTP.NET114 VPW N11LL_CKT W=0.26U L=0.04U
X_M_cka._clk._mem_gtp.MXN8 _CKA._CLK._MEM_GTP.NET114 _CKA._CLK.GTPRST VSSE VPW
+  N11LL_CKT W=0.26U L=0.04U
X_M_cka._clk._mem_gtp.MXP1 _CKA._CLK.NGTP _CKA._CLK.GTPRST VDDPE VNWP
+  P11LL_CKT W=4.26U L=0.04U
X_M_cka._clk._mem_gtp.MXP2 _CKA._CLK._MEM_GTP.NET127 _CKA._CLK._MEM_GTP.CTR
+  VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cka._clk._mem_gtp.MXP3 _CKA._CLK._MEM_GTP.NET127 CLKA VDDPE VNWP P11LL_CKT
+  W=0.48U L=0.04U
X_M_cka._clk._mem_gtp.MXP5 _CKA._CLK.NGTP _CKA._CLK._MEM_GTP.FEED
+  _CKA._CLK._MEM_GTP.NET127 VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cka._ctl_prechbl.I29.MXNA1 PRECHA_L _CKA._CTL_PRECHBL.NBLPRECH_L VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_cka._ctl_prechbl.I29.MXPA1 PRECHA_L _CKA._CTL_PRECHBL.NBLPRECH_L VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_cka._ctl_prechbl.I36.MXNA1 PRECHA_R _CKA._CTL_PRECHBL.NBLPRECH_R VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_cka._ctl_prechbl.I36.MXPA1 PRECHA_R _CKA._CTL_PRECHBL.NBLPRECH_R VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_cka._ctl_prechbl.I37.MXNA1 _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.NET0130 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I37.MXPA1 _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.NET0130 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I51.MXNA1 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I51.MXNA2 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.DRET
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I51.MXPA1 _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.I51.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I51.MXPA2 _CKA._CTL_PRECHBL.I51.P1 _CKA._CTL_PRECHBL.DRET
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I52.MXNA1 _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I52.MXNA2 _CKA._CTL_PRECHBL.DGTP_R DFTRETA VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I52.MXPA1 _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.IGTP
+  _CKA._CTL_PRECHBL.I52.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I52.MXPA2 _CKA._CTL_PRECHBL.I52.P1 DFTRETA VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_cka._ctl_prechbl.I64.MXNA1 _CKA._CTL_PRECHBL.I64.N1
+  _CKA._CTL_PRECHBL.NET039 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I64.MXNOE _CKA._CTL_PRECHBL.NET047
+  _CKA._CTL_PRECHBL.NET039 _CKA._CTL_PRECHBL.I64.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_cka._ctl_prechbl.I64.MXPA1 _CKA._CTL_PRECHBL.I64.P1
+  _CKA._CTL_PRECHBL.NET039 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I64.MXPOEN _CKA._CTL_PRECHBL.NET047
+  _CKA._CTL_PRECHBL.NET039 _CKA._CTL_PRECHBL.I64.P1 VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_cka._ctl_prechbl.I65.MXNA1 _CKA._CTL_PRECHBL.I65.N1 DFTRETA VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I65.MXNOE _CKA._CTL_PRECHBL.NET039 DFTRETA
+  _CKA._CTL_PRECHBL.I65.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I65.MXPA1 _CKA._CTL_PRECHBL.I65.P1 DFTRETA VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I65.MXPOEN _CKA._CTL_PRECHBL.NET039 DFTRETA
+  _CKA._CTL_PRECHBL.I65.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_M_cka._ctl_prechbl.I68.MXNA1 _CKA._CTL_PRECHBL.DRET _CKA._CTL_PRECHBL.NET49
+  VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_cka._ctl_prechbl.I68.MXPA1 _CKA._CTL_PRECHBL.DRET _CKA._CTL_PRECHBL.NET49
+  VDDPE VNWP P11LL_CKT W=0.34U L=0.04U
X_M_cka._ctl_prechbl.I69.MXNA1 _CKA._CTL_PRECHBL.NET49 DFTRETA VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXNA2 _CKA._CTL_PRECHBL.NET49
+  _CKA._CTL_PRECHBL.NET047 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXPA1 _CKA._CTL_PRECHBL.NET49 DFTRETA
+  _CKA._CTL_PRECHBL.I69.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I69.MXPA2 _CKA._CTL_PRECHBL.I69.P1
+  _CKA._CTL_PRECHBL.NET047 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNA1 _CKA._CTL_PRECHBL.NBLPRECH_R _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I72.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNA2 _CKA._CTL_PRECHBL.I72.A1A2
+  _CKA._CTL_PRECHBL.DGTP_R VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXNB1 _CKA._CTL_PRECHBL.NBLPRECH_R MOD_RDT_P2 VSSE
+  VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I72.MXPA1 _CKA._CTL_PRECHBL.NBLPRECH_R _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_cka._ctl_prechbl.I72.MXPA2 _CKA._CTL_PRECHBL.NBLPRECH_R
+  _CKA._CTL_PRECHBL.DGTP_R _CKA._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_cka._ctl_prechbl.I72.MXPB1 _CKA._CTL_PRECHBL.I72.A1A2UP MOD_RDT_P2 VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNA1 _CKA._CTL_PRECHBL.NBLPRECH_L _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I73.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNA2 _CKA._CTL_PRECHBL.I73.A1A2
+  _CKA._CTL_PRECHBL.DGTP_L VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXNB1 _CKA._CTL_PRECHBL.NBLPRECH_L MOD_RDT_P2 VSSE
+  VPW N11LL_CKT W=1.135U L=0.04U
X_M_cka._ctl_prechbl.I73.MXPA1 _CKA._CTL_PRECHBL.NBLPRECH_L _CKA.NGTPA
+  _CKA._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_cka._ctl_prechbl.I73.MXPA2 _CKA._CTL_PRECHBL.NBLPRECH_L
+  _CKA._CTL_PRECHBL.DGTP_L _CKA._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_cka._ctl_prechbl.I73.MXPB1 _CKA._CTL_PRECHBL.I73.A1A2UP MOD_RDT_P2 VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_cka._ctl_prechbl.I75.MXNA1 _CKA._CTL_PRECHBL.NET0130
+  _CKA._CTL_PRECHBL.NET0124 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I75.MXPA1 _CKA._CTL_PRECHBL.NET0130
+  _CKA._CTL_PRECHBL.NET0124 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_cka._ctl_prechbl.I76.MXNA1 _CKA._CTL_PRECHBL.NET0124 _CKA.NGTPA VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._ctl_prechbl.I76.MXPA1 _CKA._CTL_PRECHBL.NET0124 _CKA.NGTPA VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_cka._mem_tiehilo.MXN0 TIELODBLA _CKA._MEM_TIEHILO.NODEB VSSE VPW N11LL_CKT
+  W=1.42U L=0.04U
X_M_cka._mem_tiehilo.MXN1 _CKA._MEM_TIEHILO.NODEA _CKA._MEM_TIEHILO.NODEA VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_cka._mem_tiehilo.MXN2 _CKA._MEM_TIEHILO.NODEA _CKA._MEM_TIEHILO.NODEB VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_cka._mem_tiehilo.MXP1 _CKA._MEM_TIEHILO.NODEB _CKA._MEM_TIEHILO.NODEA
+  VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_M_cka._mem_tiehilo.MXP4 TIEHIA _CKA._MEM_TIEHILO.NODEA VDDPE VNWP P11LL_CKT
+  W=2.04U L=0.04U
X_M_cka._rdt_p2latch.I47.MXNA1 _CKA._RDT_P2LATCH.ND RDT
+  _CKA._RDT_P2LATCH.I47.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXNA2 _CKA._RDT_P2LATCH.I47.N1 _CKA.NDFTNRETA VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXPA1 _CKA._RDT_P2LATCH.ND RDT VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I47.MXPA2 _CKA._RDT_P2LATCH.ND _CKA.NDFTNRETA VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_cka._rdt_p2latch.I48.MXNOE _CKA.NET258 NCLKA _CKA._RDT_P2LATCH.ND VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_cka._rdt_p2latch.I48.MXPOEN _CKA.NET258 BCLKA _CKA._RDT_P2LATCH.ND VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_cka._rdt_p2latch.I50.MXNA1 MOD_RDT_P2 _CKA.NET258 VSSE VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_cka._rdt_p2latch.I50.MXPA1 MOD_RDT_P2 _CKA.NET258 VDDPE VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_cka._rdt_p2latch.I55.MXNA1 _CKA._RDT_P2LATCH.I55.N1 MOD_RDT_P2 VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXNOE _CKA.NET258 BCLKA _CKA._RDT_P2LATCH.I55.N1 VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXPA1 _CKA._RDT_P2LATCH.I55.P1 MOD_RDT_P2 VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_cka._rdt_p2latch.I55.MXPOEN _CKA.NET258 NCLKA _CKA._RDT_P2LATCH.I55.P1
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_M_ckb.I239_0.MXNA1 _CKB.INCAB_P2[0] _CKB.ICAB_P2[0] VSS VPW N11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I239_0.MXPA1 _CKB.INCAB_P2[0] _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb.I239_1.MXNA1 _CKB.INCAB_P2[1] _CKB.ICAB_P2[1] VSS VPW N11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I239_1.MXPA1 _CKB.INCAB_P2[1] _CKB.ICAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb.I248.MXNA1 WCLK _CKB.NET0153 VSS VPW N11LL_CKT W=2.27U L=0.04U
X_M_ckb.I248.MXPA1 WCLK _CKB.NET0153 VDDPE VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckb.I249.MXNA1 _CKB.NET0153 GTPB VSS VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb.I249.MXNA2 _CKB.NET0153 _CKB.NET0125 VSS VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb.I249.MXPA1 _CKB.NET0153 GTPB _CKB.I249.P1 VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb.I249.MXPA2 _CKB.I249.P1 _CKB.NET0125 VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb.I251.MXNA1 _CKB.DFTCLKB NCLKB VSSE VPW N11LL_CKT W=1.5U L=0.04U
X_M_ckb.I251.MXNA2 _CKB.DFTCLKB IDFTB_P2 VSSE VPW N11LL_CKT W=1.02U L=0.04U
X_M_ckb.I251.MXP0 _CKB.DFTCLKB NCLKB _CKB.I251.P2 VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I251.MXP1 _CKB.I251.P2 IDFTB_P2 VDDPE VNWP P11LL_CKT W=1.66U L=0.04U
X_M_ckb.I251.MXPA1 _CKB.DFTCLKB NCLKB _CKB.I251.P1 VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I251.MXPA2 _CKB.I251.P1 IDFTB_P2 VDDPE VNWP P11LL_CKT W=1.66U L=0.04U
X_M_ckb.I253.MXNA1 _CKB.FORCERDBL NFORCERDBL VSSE VPW N11LL_CKT W=2U L=0.04U
X_M_ckb.I253.MXPA1 _CKB.FORCERDBL NFORCERDBL VDDPE VNWP P11LL_CKT W=1.66U
+  L=0.04U
X_M_ckb.I256_0.MXNA1 _CKB.ICAB_P2[0] _CKB.NET0128[1] VSS VPW N11LL_CKT W=0.33U
+  L=0.04U
X_M_ckb.I256_0.MXPA1 _CKB.ICAB_P2[0] _CKB.NET0128[1] VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb.I256_1.MXNA1 _CKB.ICAB_P2[1] _CKB.NET0128[0] VSS VPW N11LL_CKT W=0.33U
+  L=0.04U
X_M_ckb.I256_1.MXPA1 _CKB.ICAB_P2[1] _CKB.NET0128[0] VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb.I257_0.MXNA1 _CKB.NCAB_P2[0] CAB_P2[0] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_ckb.I257_0.MXPA1 _CKB.NCAB_P2[0] CAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb.I257_1.MXNA1 _CKB.NCAB_P2[1] CAB_P2[1] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_ckb.I257_1.MXPA1 _CKB.NCAB_P2[1] CAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb.I260.MXN3 _CKB.I260.NET057 _CKB.I260.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I260.MXN4 _CKB.I260.NDI _CKB.NET061 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I260.MXN8 _CKB.NET0125 _CKB.I260.NDI _CKB.I260.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I260.MXP0 _CKB.NET0125 _CKB.I260.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I260.MXP1 _CKB.I260.NDI _CKB.NET061 _CKB.I260.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I260.MXP2 _CKB.I260.NET044 _CKB.NET061 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I261_0.MXNA1 _CKB.BCAB_P2[0] _CKB.NCAB_P2[0] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I261_0.MXPA1 _CKB.BCAB_P2[0] _CKB.NCAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_ckb.I261_1.MXNA1 _CKB.BCAB_P2[1] _CKB.NCAB_P2[1] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I261_1.MXPA1 _CKB.BCAB_P2[1] _CKB.NCAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_ckb.I262_0.MXNA1 _CKB.NET0128[1] _CKB.BCAB_P2[0] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I262_0.MXPA1 _CKB.NET0128[1] _CKB.BCAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I262_1.MXNA1 _CKB.NET0128[0] _CKB.BCAB_P2[1] VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb.I262_1.MXPA1 _CKB.NET0128[0] _CKB.BCAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.33U L=0.04U
X_M_ckb.I264.MXN3 _CKB.I264.NET057 _CKB.I264.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXN4 _CKB.I264.NDI GTPB VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I264.MXN8 _CKB.NET061 _CKB.I264.NDI _CKB.I264.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I264.MXP0 _CKB.NET061 _CKB.I264.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXP1 _CKB.I264.NDI GTPB _CKB.I264.NET044 VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I264.MXP2 _CKB.I264.NET044 GTPB VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb.I276.MXN3 _CKB.I276.NET057 _CKB.I276.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXN4 _CKB.I276.NDI _CKB.NET0125 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXN8 _CKB.NET062 _CKB.I276.NDI _CKB.I276.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I276.MXP0 _CKB.NET062 _CKB.I276.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I276.MXP1 _CKB.I276.NDI _CKB.NET0125 _CKB.I276.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I276.MXP2 _CKB.I276.NET044 _CKB.NET0125 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXN3 _CKB.I277.NET057 _CKB.I277.NDI VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXN4 _CKB.I277.NDI _CKB.NET062 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb.I277.MXN8 _CKB.NET071 _CKB.I277.NDI _CKB.I277.NET057 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I277.MXP0 _CKB.NET071 _CKB.I277.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I277.MXP1 _CKB.I277.NDI _CKB.NET062 _CKB.I277.NET044 VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb.I277.MXP2 _CKB.I277.NET044 _CKB.NET062 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb.I32.MXNA1 NCLKB GTPB VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.I32.MXPA1 NCLKB GTPB VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_ckb.I4.MXNA1 _CKB.NICLK GTPB VSS VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb.I4.MXPA1 _CKB.NICLK GTPB VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_M_ckb.I5.MXNA1 BCLKB _CKB.NICLK VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.I5.MXPA1 BCLKB _CKB.NICLK VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_ckb.I51.MXNA1 _CKB.NGTPB GTPB VSS VPW N11LL_CKT W=0.91U L=0.04U
X_M_ckb.I51.MXPA1 _CKB.NGTPB GTPB VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckb.MXN0 TIELOCDB TIEHIB VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb.MXN1 TIELOFPB TIEHIB VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[0] _CKB.ICAB_P2[1]
+  _CKB.RF2YDEC2TO4_COL.I0_0.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXP1 _CKB.RF2YDEC2TO4_COL.I0_0.P2 _CKB.ICAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[0]
+  _CKB.ICAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_0.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_0.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_0.P1
+  _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.ICAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.INCAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[1] _CKB.ICAB_P2[1]
+  _CKB.RF2YDEC2TO4_COL.I0_1.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXP1 _CKB.RF2YDEC2TO4_COL.I0_1.P2
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[1]
+  _CKB.ICAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_1.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_1.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_1.P1
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.ICAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_2.P2 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXP1 _CKB.RF2YDEC2TO4_COL.I0_2.P2 _CKB.ICAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[2]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_2.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_2.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_2.P1
+  _CKB.ICAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXNA1 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXNA2 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[0] VSS VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXP0 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_3.P2 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXP1 _CKB.RF2YDEC2TO4_COL.I0_3.P2
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXPA1 _CKB.RF2YDEC2TO4_COL.IDEC[3]
+  _CKB.INCAB_P2[1] _CKB.RF2YDEC2TO4_COL.I0_3.P1 VNWP P11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb.RF2YDec2to4_col.I0_3.MXPA2 _CKB.RF2YDEC2TO4_COL.I0_3.P1
+  _CKB.INCAB_P2[0] VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[3] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_0.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXN1 _CKB.RF2YDEC2TO4_COL.I1_0.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_0.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_0.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_0.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[3]
+  _CKB.RF2YDEC2TO4_COL.IDEC[0] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[2] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_1.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXN1 _CKB.RF2YDEC2TO4_COL.I1_1.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_1.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_1.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_1.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[2]
+  _CKB.RF2YDEC2TO4_COL.IDEC[1] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[1] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_2.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXN1 _CKB.RF2YDEC2TO4_COL.I1_2.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_2.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_2.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_2.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[1]
+  _CKB.RF2YDEC2TO4_COL.IDEC[2] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXN0 _CKB.RF2YDEC2TO4_COL.NET17[0] _CKB.FORCERDBL
+  _CKB.RF2YDEC2TO4_COL.I1_3.N2 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXN1 _CKB.RF2YDEC2TO4_COL.I1_3.N2
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXNA1 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.FORCERDBL _CKB.RF2YDEC2TO4_COL.I1_3.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXNA2 _CKB.RF2YDEC2TO4_COL.I1_3.N1
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VSS VPW N11LL_CKT W=1.42U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXPA1 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.FORCERDBL VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I1_3.MXPA2 _CKB.RF2YDEC2TO4_COL.NET17[0]
+  _CKB.RF2YDEC2TO4_COL.IDEC[3] VDDPE VNWP P11LL_CKT W=0.73U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_0.MXNA1 YPCOL[0] _CKB.RF2YDEC2TO4_COL.NET17[3]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_0.MXPA1 YPCOL[0] _CKB.RF2YDEC2TO4_COL.NET17[3]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_1.MXNA1 YPCOL[1] _CKB.RF2YDEC2TO4_COL.NET17[2]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_1.MXPA1 YPCOL[1] _CKB.RF2YDEC2TO4_COL.NET17[2]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_2.MXNA1 YPCOL[2] _CKB.RF2YDEC2TO4_COL.NET17[1]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_2.MXPA1 YPCOL[2] _CKB.RF2YDEC2TO4_COL.NET17[1]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_3.MXNA1 YPCOL[3] _CKB.RF2YDEC2TO4_COL.NET17[0]
+  VSSE VPW N11LL_CKT W=2.8U L=0.04U
X_M_ckb.RF2YDec2to4_col.I53_3.MXPA1 YPCOL[3] _CKB.RF2YDEC2TO4_COL.NET17[0]
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_0.MXNA1 YPBCLK[0] _CKB.RF2YDEC2TO4B.NET24[3] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_0.MXPA1 YPBCLK[0] _CKB.RF2YDEC2TO4B.NET24[3] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_1.MXNA1 YPBCLK[1] _CKB.RF2YDEC2TO4B.NET24[2] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_1.MXPA1 YPBCLK[1] _CKB.RF2YDEC2TO4B.NET24[2] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_2.MXNA1 YPBCLK[2] _CKB.RF2YDEC2TO4B.NET24[1] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_2.MXPA1 YPBCLK[2] _CKB.RF2YDEC2TO4B.NET24[1] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_3.MXNA1 YPBCLK[3] _CKB.RF2YDEC2TO4B.NET24[0] VSSE VPW
+  N11LL_CKT W=7.96U L=0.04U
X_M_ckb.RF2YDec2to4b.I53_3.MXPA1 YPBCLK[3] _CKB.RF2YDEC2TO4B.NET24[0] VDDPE
+  VNWP P11LL_CKT W=10U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXN0 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_0.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXN1 _CKB.RF2YDEC2TO4B.I6_0.N2
+  _CKB.RF2YDEC2TO4B.IDEC[0] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXNA1 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_0.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXNA2 _CKB.RF2YDEC2TO4B.I6_0.N1
+  _CKB.RF2YDEC2TO4B.IDEC[0] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXPA1 _CKB.RF2YDEC2TO4B.NET24[3] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_0.MXPA2 _CKB.RF2YDEC2TO4B.NET24[3]
+  _CKB.RF2YDEC2TO4B.IDEC[0] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXN0 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_1.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXN1 _CKB.RF2YDEC2TO4B.I6_1.N2
+  _CKB.RF2YDEC2TO4B.IDEC[1] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXNA1 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_1.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXNA2 _CKB.RF2YDEC2TO4B.I6_1.N1
+  _CKB.RF2YDEC2TO4B.IDEC[1] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXPA1 _CKB.RF2YDEC2TO4B.NET24[2] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_1.MXPA2 _CKB.RF2YDEC2TO4B.NET24[2]
+  _CKB.RF2YDEC2TO4B.IDEC[1] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXN0 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_2.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXN1 _CKB.RF2YDEC2TO4B.I6_2.N2
+  _CKB.RF2YDEC2TO4B.IDEC[2] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXNA1 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_2.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXNA2 _CKB.RF2YDEC2TO4B.I6_2.N1
+  _CKB.RF2YDEC2TO4B.IDEC[2] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXPA1 _CKB.RF2YDEC2TO4B.NET24[1] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_2.MXPA2 _CKB.RF2YDEC2TO4B.NET24[1]
+  _CKB.RF2YDEC2TO4B.IDEC[2] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXN0 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_3.N2 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXN1 _CKB.RF2YDEC2TO4B.I6_3.N2
+  _CKB.RF2YDEC2TO4B.IDEC[3] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXNA1 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB
+  _CKB.RF2YDEC2TO4B.I6_3.N1 VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXNA2 _CKB.RF2YDEC2TO4B.I6_3.N1
+  _CKB.RF2YDEC2TO4B.IDEC[3] VSS VPW N11LL_CKT W=1.275U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXPA1 _CKB.RF2YDEC2TO4B.NET24[0] _CKB.DFTCLKB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I6_3.MXPA2 _CKB.RF2YDEC2TO4B.NET24[0]
+  _CKB.RF2YDEC2TO4B.IDEC[3] VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXP0 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_0.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXP1 _CKB.RF2YDEC2TO4B.I7_0.P2 _CKB.BCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[0] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_0.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_0.MXPA2 _CKB.RF2YDEC2TO4B.I7_0.P1 _CKB.BCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.NCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXP0 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_1.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXP1 _CKB.RF2YDEC2TO4B.I7_1.P2 _CKB.NCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[1] _CKB.BCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_1.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_1.MXPA2 _CKB.RF2YDEC2TO4B.I7_1.P1 _CKB.NCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.BCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXP0 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_2.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXP1 _CKB.RF2YDEC2TO4B.I7_2.P2 _CKB.BCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[2] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_2.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_2.MXPA2 _CKB.RF2YDEC2TO4B.I7_2.P1 _CKB.BCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXNA1 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXNA2 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[0] VSS
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXP0 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_3.P2 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXP1 _CKB.RF2YDEC2TO4B.I7_3.P2 _CKB.NCAB_P2[0] VDDPE
+  VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXPA1 _CKB.RF2YDEC2TO4B.IDEC[3] _CKB.NCAB_P2[1]
+  _CKB.RF2YDEC2TO4B.I7_3.P1 VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb.RF2YDec2to4b.I7_3.MXPA2 _CKB.RF2YDEC2TO4B.I7_3.P1 _CKB.NCAB_P2[0]
+  VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_ckb._clk.I222.MXNA1 _CKB._CLK.GTPRST _CKB.NET217 VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk.I222.MXPA1 _CKB._CLK.GTPRST _CKB.NET217 VDDPE VNWP P11LL_CKT
+  W=0.71U L=0.04U
X_M_ckb._clk.I5.MXNA1 _CKB._CLK.NRET RET VSSE VPW N11LL_CKT W=0.16U L=0.04U
X_M_ckb._clk.I5.MXPA1 _CKB._CLK.NRET RET VDDPE VNWP P11LL_CKT W=0.155U L=0.04U
X_M_ckb._clk.I6.MXN11 _CKB._CLK.I6.NET050 _CKB._CLK.I6.DI1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN12 _CKB._CLK.I6.NDI1 SAE_DUMMY _CKB._CLK.I6.NET050 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN13 _CKB._CLK.SAE_DUMMY_OUT _CKB._CLK.I6.NDI1 VSSE VPW
+  N11LL_CKT W=0.565U L=0.04U
X_M_ckb._clk.I6.MXN3 _CKB._CLK.I6.NET057 SAEDIN VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_ckb._clk.I6.MXN4 _CKB._CLK.I6.DI1 _CKB._CLK.I6.NDI VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXN8 _CKB._CLK.I6.NDI SAEDIN _CKB._CLK.I6.NET057 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk.I6.MXP0 _CKB._CLK.I6.NDI SAEDIN VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I6.MXP1 _CKB._CLK.I6.DI1 _CKB._CLK.I6.NDI _CKB._CLK.I6.NET044
+  VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP2 _CKB._CLK.I6.NET044 _CKB._CLK.I6.NDI VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP3 _CKB._CLK.I6.NDI1 _CKB._CLK.I6.DI1 VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I6.MXP5 _CKB._CLK.SAE_DUMMY_OUT _CKB._CLK.I6.NDI1 VDDPE VNWP
+  P11LL_CKT W=0.735U L=0.04U
X_M_ckb._clk.I6.MXP6 _CKB._CLK.I6.NDI1 SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXN15 _CKB._CLK.I7.NDI0 SAEDO0 VSSE VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_ckb._clk.I7.MXN16 _CKB._CLK.I7.NET042 _CKB._CLK.I7.NDI0 VSSE VPW N11LL_CKT
+  W=0.255U L=0.04U
X_M_ckb._clk.I7.MXN4 SAEDO1 _CKB._CLK.I7.NDI VSSE VPW N11LL_CKT W=0.255U
+  L=0.04U
X_M_ckb._clk.I7.MXN8 _CKB._CLK.I7.NDI _CKB._CLK.I7.NET042 VSSE VPW N11LL_CKT
+  W=0.255U L=0.04U
X_M_ckb._clk.I7.MXP0 _CKB._CLK.I7.NDI _CKB._CLK.I7.NET042 VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk.I7.MXP1 SAEDO1 _CKB._CLK.I7.NDI VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXP8 _CKB._CLK.I7.NDI0 SAEDO0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk.I7.MXP9 _CKB._CLK.I7.NET042 _CKB._CLK.I7.NDI0 VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.I68.MXNA1 ISAE_DUM0 DBLB VSSE VPW N11LL_CKT
+  W=1.14U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.I68.MXPA1 ISAE_DUM0 DBLB VDDPE VNWP P11LL_CKT
+  W=2.265U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXN0 VSSE DBLB VSSE VPW N11LL_CKT W=2.39U L=0.085U
X_M_ckb._clk._cdm2_dummy_hd.MXN1 VSS DBLB VSS VPW N11LL_CKT W=0.285U L=0.085U
X_M_ckb._clk._cdm2_dummy_hd.MXN4_0 DBLB TIELODBLB DBLB VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXN4_1 DBLB TIELODBLB DBLB VPW N11LL_CKT W=0.465U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP1_0 DBLB TIELODBLB DBLB VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP1_1 DBLB TIELODBLB DBLB VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP2 VDDPE DBLB VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXP3 VDDPE DBLB VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXPPU1_0 DBLB TIELODBLB DBLB VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_ckb._clk._cdm2_dummy_hd.MXPPU1_1 DBLB TIELODBLB DBLB VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd.I61.MXNA1 _CKB._CLK.NET101 SAE_DUMMY VSSE VPW
+  N11LL_CKT W=1.03U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd.I61.MXPA1 _CKB._CLK.NET101 SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET40 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET045 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKMX1O _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET40 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET045 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly0.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY0.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET046 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKDLY2 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET046
+  VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET038 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD.CKDLY2 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly1.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY1.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN3
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET046 SAE_DUMMY
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET038 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN8 _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  SAE_DUMMY _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET046 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXN9
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET038 SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP0 _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET030
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rdly2.MXP4 _CKB._CLK._CK_RD_EMA47_HD.CKDLY2
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NDIN
+  _CKB._CLK._CK_RD_EMA47_HD._RDLY2.NET030 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I12.N1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I12.MXPA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I13.N1 EMAB0 VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 _CKB._CLK._CK_RD_EMA47_HD.CKDLY0 VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I13.MXPA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1 EMAB0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNA1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0 _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNA2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2 _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXNB1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK.NET101 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPA1 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A0
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPA2 _CKB._CLK._CK_RD_EMA47_HD.NET67
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.A1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I18.MXPB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.I18.A1A2UP _CKB._CLK.NET101 VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAB0 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx0.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX0.SEL_IN EMAB0 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I19.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I19.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN SAE_DUMMY VDDPE VNWP P11LL_CKT
+  W=0.45U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAB2 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN EMAB2 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I20.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.NET67
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I20.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.NET67
+  VDDPE VNWP P11LL_CKT W=0.45U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I21.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VPW N11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I21.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAB2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_IN VNWP P11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I22.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT EMAB2
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VPW N11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I22.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_DLY VNWP P11LL_CKT W=0.375U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I23.MXNA1 _CKB.NET217
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx00.I23.MXPA1 _CKB.NET217
+  _CKB._CLK._CK_RD_EMA47_HD._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I19.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I19.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN SAE_DUMMY VDDPE VNWP P11LL_CKT
+  W=0.51U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I2.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAB1 VSSE VPW N11LL_CKT W=0.12U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I2.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN EMAB1 VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I20.MXNA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I20.MXPA1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY _CKB._CLK._CK_RD_EMA47_HD.CKDLY1
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I21.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I21.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I22.MXNOE
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT EMAB1
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I22.MXPOEN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.SEL_IN
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_DLY VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I23.MXNA1 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._ck_rd_ema47_hd._rmx1.I23.MXPA1 _CKB._CLK._CK_RD_EMA47_HD.CKMX1O
+  _CKB._CLK._CK_RD_EMA47_HD._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U
+  L=0.04U
X_M_ckb._clk._dwd.MXNA1 DWLB _CKB._CLK.NGTP VSSE VPW N11LL_CKT W=2.28U L=0.04U
X_M_ckb._clk._dwd.MXPA1 DWLB _CKB._CLK.NGTP VDDP_DWLB VNWP P11LL_CKT W=5.67U
+  L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXNA1 _CKB._CLK._MEM_GTP.C1 _CKB._CLK._MEM_GTP.NCLK
+  _CKB._CLK._MEM_GTP.I1.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXNA2 _CKB._CLK._MEM_GTP.I1.N1 _CKB._CLK.NRET VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXPA1 _CKB._CLK._MEM_GTP.C1 _CKB._CLK._MEM_GTP.NCLK
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I1.MXPA2 _CKB._CLK._MEM_GTP.C1 _CKB._CLK.NRET VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNA1 _CKB._CLK._MEM_GTP.C2 BCENB
+  _CKB._CLK._MEM_GTP.I24.A1A2 VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNA2 _CKB._CLK._MEM_GTP.I24.A1A2
+  _CKB._CLK._MEM_GTP.NDFT VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXNB1 _CKB._CLK._MEM_GTP.C2 _CKB._CLK._MEM_GTP.C1
+  VSSE VPW N11LL_CKT W=0.24U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPA1 _CKB._CLK._MEM_GTP.C2 BCENB
+  _CKB._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPA2 _CKB._CLK._MEM_GTP.C2 _CKB._CLK._MEM_GTP.NDFT
+  _CKB._CLK._MEM_GTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I24.MXPB1 _CKB._CLK._MEM_GTP.I24.A1A2UP
+  _CKB._CLK._MEM_GTP.C1 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckb._clk._mem_gtp.I6.MXNA1 GTPB _CKB._CLK.NGTP VSSE VPW N11LL_CKT W=5.61U
+  L=0.04U
X_M_ckb._clk._mem_gtp.I6.MXPA1 GTPB _CKB._CLK.NGTP VDDPE VNWP P11LL_CKT
+  W=11.32U L=0.04U
X_M_ckb._clk._mem_gtp.I68.MXNA1 _CKB._CLK._MEM_GTP.FEED _CKB._CLK.NGTP VSSE
+  VPW N11LL_CKT W=0.37U L=0.04U
X_M_ckb._clk._mem_gtp.I68.MXPA1 _CKB._CLK._MEM_GTP.FEED _CKB._CLK.NGTP VDDPE
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_M_ckb._clk._mem_gtp.I7.MXNA1 _CKB._CLK._MEM_GTP.NCLK CLKB VSS VPW N11LL_CKT
+  W=4.24U L=0.04U
X_M_ckb._clk._mem_gtp.I7.MXPA1 _CKB._CLK._MEM_GTP.NCLK CLKB VDDPE VNWP
+  P11LL_CKT W=4.24U L=0.04U
X_M_ckb._clk._mem_gtp.I74.MXNA1 _CKB._CLK.NFEED _CKB._CLK._MEM_GTP.FEED VSSE
+  VPW N11LL_CKT W=0.31U L=0.04U
X_M_ckb._clk._mem_gtp.I74.MXPA1 _CKB._CLK.NFEED _CKB._CLK._MEM_GTP.FEED VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._clk._mem_gtp.I82.MXNA1 _CKB._CLK._MEM_GTP.CTR _CKB._CLK._MEM_GTP.C3
+  VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_M_ckb._clk._mem_gtp.I82.MXPA1 _CKB._CLK._MEM_GTP.CTR _CKB._CLK._MEM_GTP.C3
+  VDDPE VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXNA1 _CKB._CLK._MEM_GTP.C3 _CKB._CLK._MEM_GTP.C2
+  _CKB._CLK._MEM_GTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXNA2 _CKB._CLK._MEM_GTP.I83.N1 _CKB._CLK.NFEED VSSE
+  VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXPA1 _CKB._CLK._MEM_GTP.C3 _CKB._CLK._MEM_GTP.C2
+  VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_M_ckb._clk._mem_gtp.I83.MXPA2 _CKB._CLK._MEM_GTP.C3 _CKB._CLK.NFEED VDDPE
+  VNWP P11LL_CKT W=0.36U L=0.04U
X_M_ckb._clk._mem_gtp.I86.MXNA1 _CKB._CLK._MEM_GTP.NDFT IDFTB_P2 VSS VPW
+  N11LL_CKT W=0.21U L=0.04U
X_M_ckb._clk._mem_gtp.I86.MXPA1 _CKB._CLK._MEM_GTP.NDFT IDFTB_P2 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._mem_gtp.MXN0 _CKB._CLK._MEM_GTP.NCLK _CKB._CLK._MEM_GTP.CTR
+  _CKB._CLK.NGTP VPW N11LL_CKT W=4.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXN7 _CKB._CLK.NGTP _CKB._CLK._MEM_GTP.FEED
+  _CKB._CLK._MEM_GTP.NET114 VPW N11LL_CKT W=0.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXN8 _CKB._CLK._MEM_GTP.NET114 _CKB._CLK.GTPRST VSSE VPW
+  N11LL_CKT W=0.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXP1 _CKB._CLK.NGTP _CKB._CLK.GTPRST VDDPE VNWP
+  P11LL_CKT W=4.26U L=0.04U
X_M_ckb._clk._mem_gtp.MXP2 _CKB._CLK._MEM_GTP.NET127 _CKB._CLK._MEM_GTP.CTR
+  VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckb._clk._mem_gtp.MXP3 _CKB._CLK._MEM_GTP.NET127 CLKB VDDPE VNWP P11LL_CKT
+  W=0.48U L=0.04U
X_M_ckb._clk._mem_gtp.MXP5 _CKB._CLK.NGTP _CKB._CLK._MEM_GTP.FEED
+  _CKB._CLK._MEM_GTP.NET127 VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckb._clk._stpdly0.MXN0 _CKB._CLK._STPDLY0.NDI ISAE_DUM0
+  _CKB._CLK._STPDLY0.NET37 VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckb._clk._stpdly0.MXN3 _CKB._CLK._STPDLY0.NET37 ISAE_DUM0 VSSE VPW
+  N11LL_CKT W=0.2U L=0.04U
X_M_ckb._clk._stpdly0.MXN4 ISAE_DUM1 _CKB._CLK._STPDLY0.NDI VSSE VPW N11LL_CKT
+  W=0.62U L=0.04U
X_M_ckb._clk._stpdly0.MXP0 _CKB._CLK._STPDLY0.NDI ISAE_DUM0 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly0.MXP1 ISAE_DUM1 _CKB._CLK._STPDLY0.NDI VDDPE VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_ckb._clk._stpdly1.MXN3 VSSE ISAE_DUM1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXN4 SAEDO0 _CKB._CLK._STPDLY1.NDI VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXN8 _CKB._CLK._STPDLY1.NDI ISAE_DUM1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXP0 _CKB._CLK._STPDLY1.NDI ISAE_DUM1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_M_ckb._clk._stpdly1.MXP1 SAEDO0 _CKB._CLK._STPDLY1.NDI VDDPE VNWP P11LL_CKT
+  W=0.183U L=0.04U
X_M_ckb._clk._stpdly1.MXP2 SAEDO0 _CKB._CLK._STPDLY1.NDI VDDPE VNWP P11LL_CKT
+  W=0.183U L=0.04U
X_M_ckb._ctl_prechbl.I29.MXNA1 PRECHB_L _CKB._CTL_PRECHBL.NBLPRECH_L VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_ckb._ctl_prechbl.I29.MXPA1 PRECHB_L _CKB._CTL_PRECHBL.NBLPRECH_L VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_ckb._ctl_prechbl.I36.MXNA1 PRECHB_R _CKB._CTL_PRECHBL.NBLPRECH_R VSSE VPW
+  N11LL_CKT W=4.72U L=0.04U
X_M_ckb._ctl_prechbl.I36.MXPA1 PRECHB_R _CKB._CTL_PRECHBL.NBLPRECH_R VDDPE
+  VNWP P11LL_CKT W=5.96U L=0.04U
X_M_ckb._ctl_prechbl.I37.MXNA1 _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.NET0130 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I37.MXPA1 _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.NET0130 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXNA1 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXNA2 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.DRET
+  VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXPA1 _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.I51.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I51.MXPA2 _CKB._CTL_PRECHBL.I51.P1 _CKB._CTL_PRECHBL.DRET
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXNA1 _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.IGTP
+  VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXNA2 _CKB._CTL_PRECHBL.DGTP_R DFTRETB VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXPA1 _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.IGTP
+  _CKB._CTL_PRECHBL.I52.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I52.MXPA2 _CKB._CTL_PRECHBL.I52.P1 DFTRETB VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXNA1 _CKB._CTL_PRECHBL.I64.N1
+  _CKB._CTL_PRECHBL.NET039 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXNOE _CKB._CTL_PRECHBL.NET047
+  _CKB._CTL_PRECHBL.NET039 _CKB._CTL_PRECHBL.I64.N1 VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_ckb._ctl_prechbl.I64.MXPA1 _CKB._CTL_PRECHBL.I64.P1
+  _CKB._CTL_PRECHBL.NET039 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I64.MXPOEN _CKB._CTL_PRECHBL.NET047
+  _CKB._CTL_PRECHBL.NET039 _CKB._CTL_PRECHBL.I64.P1 VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckb._ctl_prechbl.I65.MXNA1 _CKB._CTL_PRECHBL.I65.N1 DFTRETB VSS VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXNOE _CKB._CTL_PRECHBL.NET039 DFTRETB
+  _CKB._CTL_PRECHBL.I65.N1 VPW N11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXPA1 _CKB._CTL_PRECHBL.I65.P1 DFTRETB VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I65.MXPOEN _CKB._CTL_PRECHBL.NET039 DFTRETB
+  _CKB._CTL_PRECHBL.I65.P1 VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckb._ctl_prechbl.I68.MXNA1 _CKB._CTL_PRECHBL.DRET _CKB._CTL_PRECHBL.NET49
+  VSS VPW N11LL_CKT W=0.17U L=0.04U
X_M_ckb._ctl_prechbl.I68.MXPA1 _CKB._CTL_PRECHBL.DRET _CKB._CTL_PRECHBL.NET49
+  VDDPE VNWP P11LL_CKT W=0.34U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXNA1 _CKB._CTL_PRECHBL.NET49 DFTRETB VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXNA2 _CKB._CTL_PRECHBL.NET49
+  _CKB._CTL_PRECHBL.NET047 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXPA1 _CKB._CTL_PRECHBL.NET49 DFTRETB
+  _CKB._CTL_PRECHBL.I69.P1 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I69.MXPA2 _CKB._CTL_PRECHBL.I69.P1
+  _CKB._CTL_PRECHBL.NET047 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNA1 _CKB._CTL_PRECHBL.NBLPRECH_R _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I72.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNA2 _CKB._CTL_PRECHBL.I72.A1A2
+  _CKB._CTL_PRECHBL.DGTP_R VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXNB1 _CKB._CTL_PRECHBL.NBLPRECH_R TIELODBLB VSSE VPW
+  N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPA1 _CKB._CTL_PRECHBL.NBLPRECH_R _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPA2 _CKB._CTL_PRECHBL.NBLPRECH_R
+  _CKB._CTL_PRECHBL.DGTP_R _CKB._CTL_PRECHBL.I72.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_ckb._ctl_prechbl.I72.MXPB1 _CKB._CTL_PRECHBL.I72.A1A2UP TIELODBLB VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNA1 _CKB._CTL_PRECHBL.NBLPRECH_L _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I73.A1A2 VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNA2 _CKB._CTL_PRECHBL.I73.A1A2
+  _CKB._CTL_PRECHBL.DGTP_L VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXNB1 _CKB._CTL_PRECHBL.NBLPRECH_L TIELODBLB VSSE VPW
+  N11LL_CKT W=1.135U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPA1 _CKB._CTL_PRECHBL.NBLPRECH_L _CKB.NGTPB
+  _CKB._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=2.04U L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPA2 _CKB._CTL_PRECHBL.NBLPRECH_L
+  _CKB._CTL_PRECHBL.DGTP_L _CKB._CTL_PRECHBL.I73.A1A2UP VNWP P11LL_CKT W=1.7U
+  L=0.04U
X_M_ckb._ctl_prechbl.I73.MXPB1 _CKB._CTL_PRECHBL.I73.A1A2UP TIELODBLB VDDPE
+  VNWP P11LL_CKT W=1.7U L=0.04U
X_M_ckb._ctl_prechbl.I75.MXNA1 _CKB._CTL_PRECHBL.NET0130
+  _CKB._CTL_PRECHBL.NET0124 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I75.MXPA1 _CKB._CTL_PRECHBL.NET0130
+  _CKB._CTL_PRECHBL.NET0124 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckb._ctl_prechbl.I76.MXNA1 _CKB._CTL_PRECHBL.NET0124 _CKB.NGTPB VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckb._ctl_prechbl.I76.MXPA1 _CKB._CTL_PRECHBL.NET0124 _CKB.NGTPB VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_M_ckb._iretb.MXNA1 DFTRETB _CKB.NDFTRETB VSSE VPW N11LL_CKT W=3.66U L=0.04U
X_M_ckb._iretb.MXPA1 DFTRETB _CKB.NDFTRETB VDDCE VNWC P11LL_CKT W=5.465U
+  L=0.04U
X_M_ckb._mem_tiehilo.MXN0 TIELODBLB _CKB._MEM_TIEHILO.NODEB VSSE VPW N11LL_CKT
+  W=1.42U L=0.04U
X_M_ckb._mem_tiehilo.MXN1 _CKB._MEM_TIEHILO.NODEA _CKB._MEM_TIEHILO.NODEA VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckb._mem_tiehilo.MXN2 _CKB._MEM_TIEHILO.NODEA _CKB._MEM_TIEHILO.NODEB VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckb._mem_tiehilo.MXP1 _CKB._MEM_TIEHILO.NODEB _CKB._MEM_TIEHILO.NODEA
+  VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_M_ckb._mem_tiehilo.MXP4 TIEHIB _CKB._MEM_TIEHILO.NODEA VDDPE VNWP P11LL_CKT
+  W=2.04U L=0.04U
X_M_ckb._nr_ret.MXNA1 _CKB.NDFTRETB RET VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_M_ckb._nr_ret.MXNA2 _CKB.NDFTRETB IDFTB_P2 VSSE VPW N11LL_CKT W=0.65U
+  L=0.04U
X_M_ckb._nr_ret.MXP0 _CKB.NDFTRETB RET _CKB._NR_RET.P2 VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXP1 _CKB._NR_RET.P2 IDFTB_P2 VDDCE VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXPA1 _CKB.NDFTRETB RET _CKB._NR_RET.P1 VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_ckb._nr_ret.MXPA2 _CKB._NR_RET.P1 IDFTB_P2 VDDCE VNWC P11LL_CKT W=0.91U
+  L=0.04U
X_M_coldet.I187.I81.MXNA1 _COLDET.I187.XAN RAA_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I187.I81.MXPA1 _COLDET.I187.XAN RAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I187.I82.MXNA1 _COLDET.I187.XBN RAB_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I187.I82.MXPA1 _COLDET.I187.XBN RAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I187.MXN5 _COLDET.I187.N1 RAB_P2[0] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I187.MXN6 _COLDET.XMT0 _COLDET.I187.XAN _COLDET.I187.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I187.MXN7 _COLDET.XMT0 RAA_P2[0] _COLDET.I187.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I187.MXN8 _COLDET.I187.N0 _COLDET.I187.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I187.MXP5 _COLDET.I187.P1 _COLDET.I187.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I187.MXP6 _COLDET.XMT0 _COLDET.I187.XBN _COLDET.I187.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I187.MXP7 _COLDET.XMT0 RAA_P2[0] _COLDET.I187.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I187.MXP8 _COLDET.I187.P0 RAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I188.I81.MXNA1 _COLDET.I188.XAN RAA_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I188.I81.MXPA1 _COLDET.I188.XAN RAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I188.I82.MXNA1 _COLDET.I188.XBN RAB_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I188.I82.MXPA1 _COLDET.I188.XBN RAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I188.MXN5 _COLDET.I188.N1 RAB_P2[1] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I188.MXN6 _COLDET.XMT1 _COLDET.I188.XAN _COLDET.I188.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I188.MXN7 _COLDET.XMT1 RAA_P2[1] _COLDET.I188.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I188.MXN8 _COLDET.I188.N0 _COLDET.I188.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I188.MXP5 _COLDET.I188.P1 _COLDET.I188.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I188.MXP6 _COLDET.XMT1 _COLDET.I188.XBN _COLDET.I188.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I188.MXP7 _COLDET.XMT1 RAA_P2[1] _COLDET.I188.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I188.MXP8 _COLDET.I188.P0 RAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I189.I81.MXNA1 _COLDET.I189.XAN RAA_P2[2] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I189.I81.MXPA1 _COLDET.I189.XAN RAA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I189.I82.MXNA1 _COLDET.I189.XBN RAB_P2[2] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I189.I82.MXPA1 _COLDET.I189.XBN RAB_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I189.MXN5 _COLDET.I189.N1 RAB_P2[2] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I189.MXN6 _COLDET.XMT2 _COLDET.I189.XAN _COLDET.I189.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I189.MXN7 _COLDET.XMT2 RAA_P2[2] _COLDET.I189.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I189.MXN8 _COLDET.I189.N0 _COLDET.I189.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I189.MXP5 _COLDET.I189.P1 _COLDET.I189.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I189.MXP6 _COLDET.XMT2 _COLDET.I189.XBN _COLDET.I189.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I189.MXP7 _COLDET.XMT2 RAA_P2[2] _COLDET.I189.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I189.MXP8 _COLDET.I189.P0 RAB_P2[2] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I190.I81.MXNA1 _COLDET.I190.XAN RAA_P2[5] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I190.I81.MXPA1 _COLDET.I190.XAN RAA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I190.I82.MXNA1 _COLDET.I190.XBN RAB_P2[5] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I190.I82.MXPA1 _COLDET.I190.XBN RAB_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I190.MXN5 _COLDET.I190.N1 RAB_P2[5] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I190.MXN6 _COLDET.XMT5 _COLDET.I190.XAN _COLDET.I190.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I190.MXN7 _COLDET.XMT5 RAA_P2[5] _COLDET.I190.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I190.MXN8 _COLDET.I190.N0 _COLDET.I190.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I190.MXP5 _COLDET.I190.P1 _COLDET.I190.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I190.MXP6 _COLDET.XMT5 _COLDET.I190.XBN _COLDET.I190.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I190.MXP7 _COLDET.XMT5 RAA_P2[5] _COLDET.I190.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I190.MXP8 _COLDET.I190.P0 RAB_P2[5] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I191.I81.MXNA1 _COLDET.I191.XAN RAA_P2[4] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I191.I81.MXPA1 _COLDET.I191.XAN RAA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I191.I82.MXNA1 _COLDET.I191.XBN RAB_P2[4] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I191.I82.MXPA1 _COLDET.I191.XBN RAB_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I191.MXN5 _COLDET.I191.N1 RAB_P2[4] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I191.MXN6 _COLDET.XMT4 _COLDET.I191.XAN _COLDET.I191.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I191.MXN7 _COLDET.XMT4 RAA_P2[4] _COLDET.I191.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I191.MXN8 _COLDET.I191.N0 _COLDET.I191.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I191.MXP5 _COLDET.I191.P1 _COLDET.I191.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I191.MXP6 _COLDET.XMT4 _COLDET.I191.XBN _COLDET.I191.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I191.MXP7 _COLDET.XMT4 RAA_P2[4] _COLDET.I191.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I191.MXP8 _COLDET.I191.P0 RAB_P2[4] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I192.I81.MXNA1 _COLDET.I192.XAN RAA_P2[3] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I192.I81.MXPA1 _COLDET.I192.XAN RAA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I192.I82.MXNA1 _COLDET.I192.XBN RAB_P2[3] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I192.I82.MXPA1 _COLDET.I192.XBN RAB_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I192.MXN5 _COLDET.I192.N1 RAB_P2[3] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I192.MXN6 _COLDET.XMT3 _COLDET.I192.XAN _COLDET.I192.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I192.MXN7 _COLDET.XMT3 RAA_P2[3] _COLDET.I192.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I192.MXN8 _COLDET.I192.N0 _COLDET.I192.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I192.MXP5 _COLDET.I192.P1 _COLDET.I192.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I192.MXP6 _COLDET.XMT3 _COLDET.I192.XBN _COLDET.I192.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I192.MXP7 _COLDET.XMT3 RAA_P2[3] _COLDET.I192.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I192.MXP8 _COLDET.I192.P0 RAB_P2[3] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I193.I81.MXNA1 _COLDET.I193.XAN LAA_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I193.I81.MXPA1 _COLDET.I193.XAN LAA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I193.I82.MXNA1 _COLDET.I193.XBN LAB_P2[0] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I193.I82.MXPA1 _COLDET.I193.XBN LAB_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I193.MXN5 _COLDET.I193.N1 LAB_P2[0] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I193.MXN6 _COLDET.XMT6 _COLDET.I193.XAN _COLDET.I193.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I193.MXN7 _COLDET.XMT6 LAA_P2[0] _COLDET.I193.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I193.MXN8 _COLDET.I193.N0 _COLDET.I193.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I193.MXP5 _COLDET.I193.P1 _COLDET.I193.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I193.MXP6 _COLDET.XMT6 _COLDET.I193.XBN _COLDET.I193.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I193.MXP7 _COLDET.XMT6 LAA_P2[0] _COLDET.I193.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I193.MXP8 _COLDET.I193.P0 LAB_P2[0] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I196.MXNA1 _COLDET.XMT1N _COLDET.XMT2 _COLDET.I196.N2 VPW N11LL_CKT
+  W=0.515U L=0.04U
X_M_coldet.I196.MXNA2 _COLDET.I196.N2 _COLDET.XMT1 _COLDET.I196.N1 VPW
+  N11LL_CKT W=0.515U L=0.04U
X_M_coldet.I196.MXNA3 _COLDET.I196.N1 _COLDET.XMT0 VSS VPW N11LL_CKT W=0.515U
+  L=0.04U
X_M_coldet.I196.MXPA1 _COLDET.XMT1N _COLDET.XMT2 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I196.MXPA2 _COLDET.XMT1N _COLDET.XMT1 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I196.MXPA3 _COLDET.XMT1N _COLDET.XMT0 VDDPE VNWP P11LL_CKT W=0.26U
+  L=0.04U
X_M_coldet.I199.MXNA1 _COLDET.XMT2N _COLDET.XMT5 _COLDET.I199.N2 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_M_coldet.I199.MXNA2 _COLDET.I199.N2 _COLDET.XMT4 _COLDET.I199.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_coldet.I199.MXNA3 _COLDET.I199.N1 _COLDET.XMT3 VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_coldet.I199.MXPA1 _COLDET.XMT2N _COLDET.XMT5 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I199.MXPA2 _COLDET.XMT2N _COLDET.XMT4 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I199.MXPA3 _COLDET.XMT2N _COLDET.XMT3 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I206.MXNA1 _COLDET.X1MT _COLDET.XMT2N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I206.MXNA2 _COLDET.X1MT _COLDET.XMT1N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I206.MXPA1 _COLDET.X1MT _COLDET.XMT2N _COLDET.I206.P1 VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_M_coldet.I206.MXPA2 _COLDET.I206.P1 _COLDET.XMT1N VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_M_coldet.I219.MXNA1 _COLDET.GCKMT _COLDET.GCKMTN VSSE VPW N11LL_CKT W=0.2U
+  L=0.04U
X_M_coldet.I219.MXPA1 _COLDET.GCKMT _COLDET.GCKMTN VDDPE VNWP P11LL_CKT W=0.4U
+  L=0.04U
X_M_coldet.I237.I81.MXNA1 _COLDET.I237.XAN LAA_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I237.I81.MXPA1 _COLDET.I237.XAN LAA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I237.I82.MXNA1 _COLDET.I237.XBN LAB_P2[1] VSS VPW N11LL_CKT W=0.14U
+  L=0.04U
X_M_coldet.I237.I82.MXPA1 _COLDET.I237.XBN LAB_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.26U L=0.04U
X_M_coldet.I237.MXN5 _COLDET.I237.N1 LAB_P2[1] VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_coldet.I237.MXN6 _COLDET.NET78 _COLDET.I237.XAN _COLDET.I237.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_coldet.I237.MXN7 _COLDET.NET78 LAA_P2[1] _COLDET.I237.N0 VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I237.MXN8 _COLDET.I237.N0 _COLDET.I237.XBN VSS VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_coldet.I237.MXP5 _COLDET.I237.P1 _COLDET.I237.XAN VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I237.MXP6 _COLDET.NET78 _COLDET.I237.XBN _COLDET.I237.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_coldet.I237.MXP7 _COLDET.NET78 LAA_P2[1] _COLDET.I237.P0 VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_coldet.I237.MXP8 _COLDET.I237.P0 LAB_P2[1] VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_coldet.I240.MXNA1 _COLDET.GCKMTN GTPA _COLDET.I240.N1 VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_coldet.I240.MXNA2 _COLDET.I240.N1 GTPB VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_coldet.I240.MXPA1 _COLDET.GCKMTN GTPA VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_coldet.I240.MXPA2 _COLDET.GCKMTN GTPB VDDPE VNWP P11LL_CKT W=0.5U L=0.04U
X_M_coldet.I241.MXNA1 _COLDET.XMT3N _COLDET.XMT6 _COLDET.I241.N2 VPW N11LL_CKT
+  W=0.51U L=0.04U
X_M_coldet.I241.MXNA2 _COLDET.I241.N2 _COLDET.NET78 _COLDET.I241.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_coldet.I241.MXNA3 _COLDET.I241.N1 MOD_COLDISN VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_coldet.I241.MXPA1 _COLDET.XMT3N _COLDET.XMT6 VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I241.MXPA2 _COLDET.XMT3N _COLDET.NET78 VDDPE VNWP P11LL_CKT
+  W=0.255U L=0.04U
X_M_coldet.I241.MXPA3 _COLDET.XMT3N MOD_COLDISN VDDPE VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_coldet.I244.MXNA1 _COLDET.X2MT _COLDET.XMT3N VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I244.MXPA1 _COLDET.X2MT _COLDET.XMT3N VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_coldet.I57.MXNA1 NFORCERDBL _COLDET.GCKMT _COLDET.I57.N2 VPW N11LL_CKT
+  W=0.9U L=0.04U
X_M_coldet.I57.MXNA2 _COLDET.I57.N2 _COLDET.X1MT _COLDET.I57.N1 VPW N11LL_CKT
+  W=0.9U L=0.04U
X_M_coldet.I57.MXNA3 _COLDET.I57.N1 _COLDET.X2MT VSS VPW N11LL_CKT W=0.9U
+  L=0.04U
X_M_coldet.I57.MXPA1 NFORCERDBL _COLDET.GCKMT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
X_M_coldet.I57.MXPA2 NFORCERDBL _COLDET.X1MT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
X_M_coldet.I57.MXPA3 NFORCERDBL _COLDET.X2MT VDDPE VNWP P11LL_CKT W=0.62U
+  L=0.04U
X_M_dfta_lat.I47.MXNA1 _DFTA_LAT.ND IDFT VSS VPW N11LL_CKT W=0.155U L=0.04U
X_M_dfta_lat.I47.MXPA1 _DFTA_LAT.ND IDFT VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_dfta_lat.I48.MXNOE NET0250 NCLKA _DFTA_LAT.ND VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_dfta_lat.I48.MXPOEN NET0250 BCLKA _DFTA_LAT.ND VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_M_dfta_lat.I50.MXNA1 DFTA_P2 NET0250 VSS VPW N11LL_CKT W=0.23U L=0.04U
X_M_dfta_lat.I50.MXPA1 DFTA_P2 NET0250 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_M_dfta_lat.I55.MXNA1 _DFTA_LAT.I55.N1 DFTA_P2 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_dfta_lat.I55.MXNOE NET0250 BCLKA _DFTA_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_dfta_lat.I55.MXPA1 _DFTA_LAT.I55.P1 DFTA_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_dfta_lat.I55.MXPOEN NET0250 NCLKA _DFTA_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_dftb_lat.I47.MXNA1 _DFTB_LAT.ND IDFT VSS VPW N11LL_CKT W=0.2U L=0.04U
X_M_dftb_lat.I47.MXPA1 _DFTB_LAT.ND IDFT VDDPE VNWP P11LL_CKT W=0.345U L=0.04U
X_M_dftb_lat.I48.MXNOE NET0586 NCLKB _DFTB_LAT.ND VPW N11LL_CKT W=0.26U
+  L=0.04U
X_M_dftb_lat.I48.MXPOEN NET0586 BCLKB _DFTB_LAT.ND VNWP P11LL_CKT W=0.255U
+  L=0.04U
X_M_dftb_lat.I50.MXNA1 IDFTB_P2 NET0586 VSS VPW N11LL_CKT W=0.59U L=0.04U
X_M_dftb_lat.I50.MXPA1 IDFTB_P2 NET0586 VDDPE VNWP P11LL_CKT W=1.02U L=0.04U
X_M_dftb_lat.I55.MXNA1 _DFTB_LAT.I55.N1 IDFTB_P2 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_dftb_lat.I55.MXNOE NET0586 BCLKB _DFTB_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_dftb_lat.I55.MXPA1 _DFTB_LAT.I55.P1 IDFTB_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_dftb_lat.I55.MXPOEN NET0586 NCLKB _DFTB_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_scanlogic._scanlogic.I2.MXNA1 SEL_SIB _SCANLOGIC._SCANLOGIC.NSE VSS VPW
+  N11LL_CKT W=2.9U L=0.04U
X_M_scanlogic._scanlogic.I2.MXPA1 SEL_SIB _SCANLOGIC._SCANLOGIC.NSE VDDPE VNWP
+  P11LL_CKT W=5.1U L=0.04U
X_M_scanlogic._scanlogic.I4.MXNA1 SEL_TD _SCANLOGIC._SCANLOGIC.NET18 VSS VPW
+  N11LL_CKT W=2.9U L=0.04U
X_M_scanlogic._scanlogic.I4.MXPA1 SEL_TD _SCANLOGIC._SCANLOGIC.NET18 VDDPE
+  VNWP P11LL_CKT W=5.1U L=0.04U
X_M_scanlogic._scanlogic.I5.MXNA1 SEL_D _SCANLOGIC._SCANLOGIC.TE VSS VPW
+  N11LL_CKT W=2.9U L=0.04U
X_M_scanlogic._scanlogic.I5.MXPA1 SEL_D _SCANLOGIC._SCANLOGIC.TE VDDPE VNWP
+  P11LL_CKT W=5.1U L=0.04U
X_M_scanlogic._scanlogic.I7.MXNA1 _SCANLOGIC._SCANLOGIC.NSE SEB VSS VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_scanlogic._scanlogic.I7.MXPA1 _SCANLOGIC._SCANLOGIC.NSE SEB VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_scanlogic._scanlogic.I8.MXNA1 _SCANLOGIC._SCANLOGIC.NET18
+  _SCANLOGIC._SCANLOGIC.NSE _SCANLOGIC._SCANLOGIC.I8.N1 VPW N11LL_CKT
+  W=0.595U L=0.04U
X_M_scanlogic._scanlogic.I8.MXNA2 _SCANLOGIC._SCANLOGIC.I8.N1
+  _SCANLOGIC._SCANLOGIC.TE VSS VPW N11LL_CKT W=0.595U L=0.04U
X_M_scanlogic._scanlogic.I8.MXPA1 _SCANLOGIC._SCANLOGIC.NET18
+  _SCANLOGIC._SCANLOGIC.NSE VDDPE VNWP P11LL_CKT W=0.91U L=0.04U
X_M_scanlogic._scanlogic.I8.MXPA2 _SCANLOGIC._SCANLOGIC.NET18
+  _SCANLOGIC._SCANLOGIC.TE VDDPE VNWP P11LL_CKT W=0.91U L=0.04U
X_M_scanlogic._scanlogic.I83.MXNA1 _SCANLOGIC._SCANLOGIC.TE
+  _SCANLOGIC._SCANLOGIC.NSE _SCANLOGIC._SCANLOGIC.I83.N1 VPW N11LL_CKT
+  W=0.595U L=0.04U
X_M_scanlogic._scanlogic.I83.MXNA2 _SCANLOGIC._SCANLOGIC.I83.N1 ITENB VSS VPW
+  N11LL_CKT W=0.595U L=0.04U
X_M_scanlogic._scanlogic.I83.MXPA1 _SCANLOGIC._SCANLOGIC.TE
+  _SCANLOGIC._SCANLOGIC.NSE VDDPE VNWP P11LL_CKT W=0.91U L=0.04U
X_M_scanlogic._scanlogic.I83.MXPA2 _SCANLOGIC._SCANLOGIC.TE ITENB VDDPE VNWP
+  P11LL_CKT W=0.91U L=0.04U
.ENDS RAMTP128X16CKM2_BSTWM
****
.SUBCKT RAMTP128X16CTRL_COLT CAA0 CAB0 CENA CENB CLKA CLKB COLLDISN DBLA DBLB
+  DFTRETA DFTRETB DWLA DWLAV DWLB DWLBTURN EMAA0 EMAA1 EMAA2 EMAB0 EMAB1
+  EMAB2 GTPA GTPB IDFT IDFTA_P2 ISIA0 ISIA1 ITEB LAA0 LAA1 LAA_P2[0]
+  LAA_P2[1] LAB0 LAB1 LAB_P2[0] LAB_P2[1] NSAE NYPACLK[0] NYPACLK[1] PRECHA_L
+  PRECHA_R PRECHB_L PRECHB_R RAA0 RAA1 RAA2 RAA3 RAA_P2[0] RAA_P2[1]
+  RAA_P2[2] RAA_P2[3] RAA_P2[4] RAA_P2[5] RAB0 RAB1 RAB2 RAB3 RAB_P2[0]
+  RAB_P2[1] RAB_P2[2] RAB_P2[3] RAB_P2[4] RAB_P2[5] RET1N SAPRECH SEL_D
+  SEL_SIB SEL_TD TIEHIA TIEHIB TIELOCDA TIELOCDB TIELODBLA TIELODBLB TIELOFPA
+  TIELOFPB TWEN VDDC_WLA VNWC VNWP VPW WCLK WEN WENSHF1TERM WENSHF2TERM
+  YPBCLK[0] YPBCLK[1] YPCOL[0] YPCOL[1]
** RAMTP128X16CTRL_COLT: 1528 flat devices **
XCKCELL CAA0 TIELOFPA CAB0 TIELOFPB CAYA0 CAYA1 CAYB0 CAYB1 CENA CENB CENYA
+  CENYB CLKA CLKB COLLDISN DBLA DBLB TIELOFPB DFTRETA DFTRETB DWLA DWLAV
+  DWLAV DWLB DWLBTURN DWLBTURN EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA GTPB
+  IDFT IDFTA_P2 ISAE_DUM0 ISAE_DUM1 ISIA0 ISIA1 ITEB LAA0 LAA1 LAA_P2[0]
+  LAA_P2[1] LAB0 LAB1 LAB_P2[0] LAB_P2[1] LAYA0 LAYA1 LAYB0 LAYB1 VPW VPW
+  NSAE NYPACLK[0] NYPACLK[1] PRECHA_L PRECHA_R PRECHB_L PRECHB_R RAA0 RAA1
+  RAA2 RAA3 TIELOFPA TIELOFPA RAA_P2[0] RAA_P2[1] RAA_P2[2] RAA_P2[3]
+  RAA_P2[4] RAA_P2[5] RAB0 RAB1 RAB2 RAB3 TIELOFPB TIELOFPB RAB_P2[0]
+  RAB_P2[1] RAB_P2[2] RAB_P2[3] RAB_P2[4] RAB_P2[5] RAYA0 RAYA1 RAYA2 RAYA3
+  RAYA4 RAYA5 RAYB0 RAYB1 RAYB2 RAYB3 RAYB4 RAYB5 TIELOFPA RET1N SAEDIN
+  SAEDIN SAEDO1 ISAE_DUM1 SAPRECH TIELOFPB TIELOFPB SEL_D SEL_SIB SEL_TD
+  TIELOFPA TIELOFPB TIELOFPA TIELOFPB TIELOFPA TIELOFPA TIELOFPB TIELOFPB
+  TIEHIA TIEHIB TIEHIA TIEHIB TIEHIA TIEHIB TIELOCDA TIELOCDB TIELODBLA
+  TIELODBLB TIELOFPA TIELOFPB TIELOFPA TIELOFPA TIELOFPB TIELOFPB TIELOFPA
+  TIELOFPA TIELOFPA TIELOFPA TIELOFPA TIELOFPA TIELOFPB TIELOFPB TIELOFPB
+  TIELOFPB TIELOFPB TIELOFPB TWEN VDDC_WLA VDDC_WLA VDDC_WLA VNWP VNWP VNWP
+  VNWC VNWP VPW VPW VPW WCLK WEN WENSHF1TERM WENSHF2TERM YPBCLK[0] YPBCLK[1]
+  YPCOL[0] YPCOL[1] RAMTP128X16CKM2_BSTWM
XFPCTRLCELL CAA0 TIELOFPA CAB0 TIELOFPB CAYA0 CAYA1 CAYB0 CAYB1 CENA CENB
+  CENYA CENYB CLKA CLKB COLLDISN VPW VPW TIELOFPB EMAA0 EMAA1 EMAA2 EMAB0
+  EMAB1 EMAB2 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW LAA0
+  LAA1 LAB0 LAB1 LAYA0 LAYA1 LAYB0 LAYB1 VPW VPW VNWP VNWP VPW VPW RAA0 RAA1
+  RAA2 RAA3 TIELOFPA TIELOFPA RAB0 RAB1 RAB2 RAB3 TIELOFPB TIELOFPB RAYA0
+  RAYA1 RAYA2 RAYA3 RAYA4 RAYA5 RAYB0 RAYB1 RAYB2 RAYB3 RAYB4 RAYB5 TIELOFPA
+  RET1N VPW TIELOFPB TIELOFPB TIELOFPA TIELOFPB TIELOFPA TIELOFPB TIELOFPA
+  TIELOFPA TIELOFPB TIELOFPB TIEHIA TIEHIB TIEHIA TIEHIB TIELOFPA TIELOFPB
+  TIELOFPA TIELOFPA TIELOFPB TIELOFPB VPW TIELOFPA TIELOFPA TIELOFPA TIELOFPA
+  TIELOFPA TIELOFPA TIELOFPB TIELOFPB TIELOFPB TIELOFPB TIELOFPB TIELOFPB
+  VDDC_WLA VNWP VNWC VNWP VPW VPW VPW RAMTP128X16FPCTRL_OPT
.ENDS RAMTP128X16CTRL_COLT
****
.SUBCKT RAMTP128X16CORE_COLX_R BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1
+  BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5
+  NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6
+  NBLB1_7 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WLA0_0 WLA0_1
+  WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11
+  WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20
+  WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29
+  WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7
+  WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16
+  WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25
+  WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3
+  WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13
+  WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22
+  WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31
+  WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9
+  WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18
+  WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27
+  WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16CORE_COLX_R: 8576 flat devices **
XCC2X2_COL_FARWD BLA0_7 BLA1_7 BLB0_7 BLB1_7 NBLA0_7 NBLA1_7 NBLB0_7 NBLB1_7
+  VDDC VDDPE_7 VPW VSS_7 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XCC2X2_COL_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 NBLA0_0 NBLA1_0 NBLB0_0 NBLB1_0
+  VDDC VDDPE_0 VPW VSS_0 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_1 BLA0_1 BLA1_1 BLB0_1 BLB1_1 NBLA0_1 NBLA1_1 NBLB0_1 NBLB1_1
+  VDDC VDDPE_1 VPW VSS_1 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  VDDC VDDPE_2 VPW VSS_2 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  VDDC VDDPE_3 VPW VSS_3 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  VDDC VDDPE_4 VPW VSS_4 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  VDDC VDDPE_5 VPW VSS_5 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
XRCC_COL_MUX1_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  VDDC VDDPE_6 VPW VSS_6 WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CC_COL_MUX1
.ENDS RAMTP128X16CORE_COLX_R
****
.SUBCKT RAMTP128X16CORE_COLXR BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW
+  WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9
+  WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18
+  WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27
+  WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5
+  WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15
+  WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24
+  WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1
+  WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11
+  WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20
+  WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29
+  WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7
+  WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16
+  WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25
+  WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
** RAMTP128X16CORE_COLXR: 8576 flat devices **
XCORE_COLXS_R BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5
+  NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6
+  NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6
+  WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15
+  WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24
+  WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1
+  WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11
+  WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20
+  WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29
+  WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7
+  WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16
+  WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25
+  WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22
+  WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31
+  RAMTP128X16CORE_COLX_R
.ENDS RAMTP128X16CORE_COLXR
****
.SUBCKT RAMTP128X16CD_COLXREG_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5
+  BLA0_6 BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7
+  BLB0_0 BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1
+  BLB1_2 BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2
+  NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3
+  NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4
+  NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5
+  NBLB1_6 NBLB1_7 NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4
+  NWRDATA_5 NWRDATA_6 NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1
+  RD_2 RD_3 RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4
+  VDDC_5 VDDC_6 VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3
+  WRDATA_4 WRDATA_5 WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16CD_COLXREG_RT: 664 flat devices **
XCD_1 BLA0_1 BLA1_1 BLB0_1 BLB1_1 DFT DWL DWL NBLA0_1 NBLA1_1 NBLB0_1 NBLB1_1
+  NSAE NWRDATA_1 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_1 SAPRECH RD_0 RD_1 TIELO
+  VDDC_1 VDDCE_1 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_1 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_2 BLA0_2 BLA1_2 BLB0_2 BLB1_2 DFT DWL DWL NBLA0_2 NBLA1_2 NBLB0_2 NBLB1_2
+  NSAE NWRDATA_2 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_2 SAPRECH RD_1 RD_2 TIELO
+  VDDC_2 VDDCE_2 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_2 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_3 BLA0_3 BLA1_3 BLB0_3 BLB1_3 DFT DWL DWL NBLA0_3 NBLA1_3 NBLB0_3 NBLB1_3
+  NSAE NWRDATA_3 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_3 SAPRECH RD_2 RD_3 TIELO
+  VDDC_3 VDDCE_3 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_3 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_4 BLA0_4 BLA1_4 BLB0_4 BLB1_4 DFT DWL DWL NBLA0_4 NBLA1_4 NBLB0_4 NBLB1_4
+  NSAE NWRDATA_4 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_4 SAPRECH RD_3 RD_4 TIELO
+  VDDC_4 VDDCE_4 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_4 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_5 BLA0_5 BLA1_5 BLB0_5 BLB1_5 DFT DWL DWL NBLA0_5 NBLA1_5 NBLB0_5 NBLB1_5
+  NSAE NWRDATA_5 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_5 SAPRECH RD_4 RD_5 TIELO
+  VDDC_5 VDDCE_5 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_5 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_6 BLA0_6 BLA1_6 BLB0_6 BLB1_6 DFT DWL DWL NBLA0_6 NBLA1_6 NBLB0_6 NBLB1_6
+  NSAE NWRDATA_6 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_6 SAPRECH RD_5 RD_6 TIELO
+  VDDC_6 VDDCE_6 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_6 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_FARWD BLA0_7 BLA1_7 BLB0_7 BLB1_7 DFT DWL DWL NBLA0_7 NBLA1_7 NBLB0_7
+  NBLB1_7 NSAE NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB SO SAPRECH RD_6 SO
+  TIELO VDDC_7 VDDCE_7 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_7 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
XCD_NEARWD BLA0_0 BLA1_0 BLB0_0 BLB1_0 DFT DWL DWL NBLA0_0 NBLA1_0 NBLB0_0
+  NBLB1_0 NSAE NWRDATA_0 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 SAPRECH SI RD_0
+  TIELO VDDC_0 VDDCE_0 VDDPE VNWC VDDPE VPW VPW VPW WRDATA_0 YPCLK0B YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 RAMTP128X16CDM2_BST
.ENDS RAMTP128X16CD_COLXREG_RT
****
.SUBCKT RAMTP128X16CD_COLX_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3
+  NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4
+  NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5
+  NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6
+  NBLB1_7 NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5
+  NWRDATA_6 NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3
+  RD_4 RD_5 RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16CD_COLX_RT: 664 flat devices **
XCD_COLXREG_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5
+  RD_6 SAPRECH SI SO TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7
+  VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
+  RAMTP128X16CD_COLXREG_RT
.ENDS RAMTP128X16CD_COLX_RT
****
.SUBCKT RAMTP128X16WRGRTNHD D Q TIELO VDDCE VDDPE VNWP VPW VSS WEN WENY
** RAMTP128X16WRGRTNHD: 4 flat devices **
XI0 D Q TIELO TIELO TIELO VDDCE VDDPE VNWP VPW VSS VSS WEN WENY
+  RAMTP128X16FLBIOM2
.ENDS RAMTP128X16WRGRTNHD
****
.SUBCKT RAMTP128X16XR_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 TIELO VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VNWP VPW VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0
+  WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3
+  WEN_4 WEN_5 WEN_6 WEN_7
** RAMTP128X16XR_COLX_RT: 32 flat devices **
XI0 D_0 Q_0 TIELO VDDCE_0 VDDPE_0 VNWP VPW VSS_0 WEN_0 WENY_0
+  RAMTP128X16WRGRTNHD
XI1 D_1 Q_1 TIELO VDDCE_1 VDDPE_1 VNWP VPW VSS_1 WEN_1 WENY_1
+  RAMTP128X16WRGRTNHD
XI2 D_2 Q_2 TIELO VDDCE_2 VDDPE_2 VNWP VPW VSS_2 WEN_2 WENY_2
+  RAMTP128X16WRGRTNHD
XI3 D_3 Q_3 TIELO VDDCE_3 VDDPE_3 VNWP VPW VSS_3 WEN_3 WENY_3
+  RAMTP128X16WRGRTNHD
XI4 D_4 Q_4 TIELO VDDCE_4 VDDPE_4 VNWP VPW VSS_4 WEN_4 WENY_4
+  RAMTP128X16WRGRTNHD
XI5 D_5 Q_5 TIELO VDDCE_5 VDDPE_5 VNWP VPW VSS_5 WEN_5 WENY_5
+  RAMTP128X16WRGRTNHD
XI6 D_6 Q_6 TIELO VDDCE_6 VDDPE_6 VNWP VPW VSS_6 WEN_6 WENY_6
+  RAMTP128X16WRGRTNHD
XI7 D_7 Q_7 TIELO VDDCE_7 VDDPE_7 VNWP VPW VSS_7 WEN_7 WENY_7
+  RAMTP128X16WRGRTNHD
.ENDS RAMTP128X16XR_COLX_RT
****
.SUBCKT RAMTP128X16WR_COLX_R DFTB D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1
+  RD_2 RD_3 RD_4 RD_5 RD_6 RD_7 SEL_D SEL_SI SEL_TD SI SO TD_0 TD_1 TD_2 TD_3
+  TD_4 TD_5 TD_6 TD_7 TE TWENL TWENR TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4
+  TWEN_5 TWEN_6 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDPE VNWP VPW WCLK WENL WENR WENY_0 WENY_1 WENY_2 WENY_3 WENY_4
+  WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WRONE_0
+  WRONE_1 WRONE_2 WRONE_3 WRONE_4 WRONE_5 WRONE_6 WRONE_7 WRZERO_0 WRZERO_1
+  WRZERO_2 WRZERO_3 WRZERO_4 WRZERO_5 WRZERO_6 WRZERO_7
** RAMTP128X16WR_COLX_R: 736 flat devices **
XWR_1 D_1 DFTB RD_1 SEL_D SEL_SI SEL_TD SO_0 SO_4 TD_1 TE TWEN_1 TWEN_0 TWEN_1
+  VDDCE_1 VDDPE VNWP VPW VPW VPW WCLK WEN_1 WEN_0 WEN_1 WENY_1 WRONE_1
+  WRZERO_1 RAMTP128X16WRM2_BSTWM
XWR_2 D_2 DFTB RD_2 SEL_D SEL_SI SEL_TD SO_4 SO_6 TD_2 TE TWEN_2 TWEN_1 TWEN_2
+  VDDCE_2 VDDPE VNWP VPW VPW VPW WCLK WEN_2 WEN_1 WEN_2 WENY_2 WRONE_2
+  WRZERO_2 RAMTP128X16WRM2_BSTWM
XWR_3 D_3 DFTB RD_3 SEL_D SEL_SI SEL_TD SO_6 SO_8 TD_3 TE TWEN_3 TWEN_2 TWEN_3
+  VDDCE_3 VDDPE VNWP VPW VPW VPW WCLK WEN_3 WEN_2 WEN_3 WENY_3 WRONE_3
+  WRZERO_3 RAMTP128X16WRM2_BSTWM
XWR_4 D_4 DFTB RD_4 SEL_D SEL_SI SEL_TD SO_8 SO_10 TD_4 TE TWEN_4 TWEN_3
+  TWEN_4 VDDCE_4 VDDPE VNWP VPW VPW VPW WCLK WEN_4 WEN_3 WEN_4 WENY_4 WRONE_4
+  WRZERO_4 RAMTP128X16WRM2_BSTWM
XWR_5 D_5 DFTB RD_5 SEL_D SEL_SI SEL_TD SO_10 SO_12 TD_5 TE TWEN_5 TWEN_4
+  TWEN_5 VDDCE_5 VDDPE VNWP VPW VPW VPW WCLK WEN_5 WEN_4 WEN_5 WENY_5 WRONE_5
+  WRZERO_5 RAMTP128X16WRM2_BSTWM
XWR_6 D_6 DFTB RD_6 SEL_D SEL_SI SEL_TD SO_12 SI_2 TD_6 TE TWEN_6 TWEN_5
+  TWEN_6 VDDCE_6 VDDPE VNWP VPW VPW VPW WCLK WEN_6 WEN_5 WEN_6 WENY_6 WRONE_6
+  WRZERO_6 RAMTP128X16WRM2_BSTWM
XWR_FARWD D_7 DFTB RD_7 SEL_D SEL_SI SEL_TD SI_2 SO TD_7 TE TWENR TWEN_6 TWENR
+  VDDCE_7 VDDPE VNWP VPW VPW VPW WCLK WENR WEN_6 WENR WENY_7 WRONE_7 WRZERO_7
+  RAMTP128X16WRM2_BSTWM
XWR_NEARWD D_0 DFTB RD_0 SEL_D SEL_SI SEL_TD SI SO_0 TD_0 TE TWEN_0 TWENL
+  TWEN_0 VDDCE_0 VDDPE VNWP VPW VPW VPW WCLK WEN_0 WENL WEN_0 WENY_0 WRONE_0
+  WRZERO_0 RAMTP128X16WRM2_BSTWM
.ENDS RAMTP128X16WR_COLX_R
****
.SUBCKT RAMTP128X16RD_COLX_R D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 RD0_0 RD0_1 RD0_2 RD0_3 RD0_4 RD0_5 RD0_6 RD0_7 TD_0 TD_1
+  TD_2 TD_3 TD_4 TD_5 TD_6 TD_7 TWEN_0 TWEN_1 TWEN_2 TWEN_3 TWEN_4 TWEN_5
+  TWEN_6 TWEN_7 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VPW_0 VPW_1 VPW_2
+  VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VSSE_0 VSSE_1 VSSE_2 VSSE_3 VSSE_4 VSSE_5
+  VSSE_6 VSSE_7 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7 WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7
** RAMTP128X16RD_COLX_R: 16 flat devices **
XRD_1 D_1 Q_1 RD0_1 TD_1 TWEN_1 VDDCE_1 VDDPE_1 VNWP_1 VPW_1 VSS_1 VSSE_1
+  WEN_1 WENY_1 RAMTP128X16RDM2
XRD_2 D_2 Q_2 RD0_2 TD_2 TWEN_2 VDDCE_2 VDDPE_2 VNWP_2 VPW_2 VSS_2 VSSE_2
+  WEN_2 WENY_2 RAMTP128X16RDM2
XRD_3 D_3 Q_3 RD0_3 TD_3 TWEN_3 VDDCE_3 VDDPE_3 VNWP_3 VPW_3 VSS_3 VSSE_3
+  WEN_3 WENY_3 RAMTP128X16RDM2
XRD_4 D_4 Q_4 RD0_4 TD_4 TWEN_4 VDDCE_4 VDDPE_4 VNWP_4 VPW_4 VSS_4 VSSE_4
+  WEN_4 WENY_4 RAMTP128X16RDM2
XRD_5 D_5 Q_5 RD0_5 TD_5 TWEN_5 VDDCE_5 VDDPE_5 VNWP_5 VPW_5 VSS_5 VSSE_5
+  WEN_5 WENY_5 RAMTP128X16RDM2
XRD_6 D_6 Q_6 RD0_6 TD_6 TWEN_6 VDDCE_6 VDDPE_6 VNWP_6 VPW_6 VSS_6 VSSE_6
+  WEN_6 WENY_6 RAMTP128X16RDM2
XRD_FARWD D_7 Q_7 RD0_7 TD_7 TWEN_7 VDDCE_7 VDDPE_7 VNWP_7 VPW_7 VSS_7 VSSE_7
+  WEN_7 WENY_7 RAMTP128X16RDM2
XRD_NEARWD D_0 Q_0 RD0_0 TD_0 TWEN_0 VDDCE_0 VDDPE_0 VNWP_0 VPW_0 VSS_0 VSSE_0
+  WEN_0 WENY_0 RAMTP128X16RDM2
.ENDS RAMTP128X16RD_COLX_R
****
.SUBCKT RAMTP128X16ENDBOT_COL_RT DFT_0 DFT_1 DWL DWLTURN NSAE_TERM NYP0A_TERM
+  NYP0B_TERM NYP1A_TERM NYP1B_TERM NYPCOL0 NYPCOL1 PRECHA_TERM PRECHB_TERM
+  SAPRECH_TERM SEL_D SEL_SI SEL_TD SIA SIB TE TIELO_0 TIELO_1 TWEN VDDCE
+  VDDPE VNWC VNWP VPW_0 VPW_1 VSSE VSS_0 VSS_1 WCLK WEN
** RAMTP128X16ENDBOT_COL_RT: 10 flat devices **
XCDEDGECELL DFT_1 DWL DWLTURN NSAE_TERM NYP0A_TERM NYP0B_TERM NYP1A_TERM
+  NYP1B_TERM NYPCOL0 NYPCOL1 PRECHA_TERM PRECHB_TERM SAPRECH_TERM SIA SIB SOA
+  SOB TIELO_1 VDDCE VDDPE VNWC VDDPE VPW_0 VSS_1 VSSE RAMTP128X16CDM2EDGE_BST
.ENDS RAMTP128X16ENDBOT_COL_RT
****
.SUBCKT RAMTP128X16BOT_IO_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6
+  BLA0_7 BLA1_0 BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0
+  BLB0_1 BLB0_2 BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2
+  BLB1_3 BLB1_4 BLB1_5 BLB1_6 BLB1_7 DFT DFTB DWL D_0 D_1 D_2 D_3 D_4 D_5 D_6
+  D_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0
+  NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1
+  NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2
+  NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NSAE NYPCLK0A NYPCLK1A PRECHA
+  PRECHB Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 SAPRECH SEL_D SEL_SI SEL_TD SI_0
+  SI_1 TE TIELO_0 TIELO_1 TWENL VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDPE VNWC VPW VSSE WCLK WENL WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
** RAMTP128X16BOT_IO_RT: 1458 flat devices **
XCD_COLX_RT BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 DFT DWL NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4
+  NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5
+  NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6
+  NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7
+  NSAE NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5 NWRDATA_6
+  NWRDATA_7 NYPCLK0A NYPCLK1A PRECHA PRECHB RD_0 RD_1 RD_2 RD_3 RD_4 RD_5
+  RD_6 SAPRECH SI_1 SO TIELO_1 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDPE VNWC VPW WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5
+  WRDATA_6 WRDATA_7 YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1 RAMTP128X16CD_COLX_RT
XENDBOT_COL_RT DFTB DFT DWL DWL NSAE NYPCLK0A YPCLK0B NYPCLK1A YPCLK1B
+  YPCOLCLK0 YPCOLCLK1 PRECHA PRECHB SAPRECH SEL_D SEL_SI SEL_TD SO SO_32 TE
+  TIELO_0 TIELO_1 TIELO_0 VDDCE_8 VDDPE VNWC VDDPE VPW VPW VSSE VPW VPW WCLK
+  WEN_7 RAMTP128X16ENDBOT_COL_RT
XRD_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  RD_0 RD_1 RD_2 RD_3 RD_4 RD_5 RD_6 SO TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WEN_7 RAMTP128X16RD_COLX_R
XWR_COLX_RT DFTB D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 RD_0 RD_1 RD_2 RD_3 RD_4 RD_5
+  RD_6 SO SEL_D SEL_SI SEL_TD SI_0 SO_32 TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 TIELO_0 TE TWENL TIELO_0 TIELO_0 TIELO_0 TIELO_0
+  TIELO_0 TIELO_0 TIELO_0 TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDPE VDDPE VPW WCLK WENL WEN_7 WENY_0 WENY_1
+  WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7 WEN_0 WEN_1 WEN_2 WEN_3 WEN_4
+  WEN_5 WEN_6 WRDATA_0 WRDATA_1 WRDATA_2 WRDATA_3 WRDATA_4 WRDATA_5 WRDATA_6
+  WRDATA_7 NWRDATA_0 NWRDATA_1 NWRDATA_2 NWRDATA_3 NWRDATA_4 NWRDATA_5
+  NWRDATA_6 NWRDATA_7 RAMTP128X16WR_COLX_R
XR_COLX_RT D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  TIELO_0 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW WENY_0 WENY_1 WENY_2 WENY_3 WENY_4 WENY_5 WENY_6 WENY_7
+  WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7 RAMTP128X16XR_COLX_RT
.ENDS RAMTP128X16BOT_IO_RT
****
.SUBCKT RAMTP128X16TTOP CAA0 CAB0 CENA CENB CLKA CLKB COLLDISN D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMAA0 EMAA1 EMAA2
+  EMAB0 EMAB1 EMAB2 LAA0 LAA1 LAB0 LAB1 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8
+  Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 RAA0 RAA1 RAA2 RAA3 RAB0 RAB1 RAB2 RAB3
+  RET1N VDDCE VDDPE VSSE WEN_0 WEN_1 WEN_2 WEN_3 WEN_4 WEN_5 WEN_6 WEN_7
+  WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
** RAMTP128X16TTOP: 23507 flat devices **
XBOT_CTRL_COL CAA0 CAB0 CENA CENB CLKA CLKB COLLDISN DBLA_OUT DBLB RETA RETB
+  DWLA DWLA DWLB DWLB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA1 GTPB0 DFTB
+  DFT SI_1 ISIA1 TE LAA0 LAA1 LAA[0] LAA[1] LAB0 LAB1 LAB[0] LAB[1] NSAE
+  NYPCLK0A NYPCLK1A PRECHA PRECHA_R PRECHB PRECHB_R RAA0 RAA1 RAA2 RAA3
+  RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB0 RAB1 RAB2 RAB3 RAB[0] RAB[1]
+  RAB[2] RAB[3] RAB[4] RAB[5] RET1N SAPRECH SEL_D SEL_SI SEL_TD LOG1A LOG1B
+  TIELO_1 TIELOCDB LOG0_DWLA LOG0_DWLB SI_0 TIELOFPB SI_0 VDDCE VDDCE VDDPE
+  VSSE WCLK WEN_7 VDDPE VDDPE YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1
+  RAMTP128X16CTRL_COLT
XCORE_COLL BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 NBLA0_0 NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5
+  NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1 NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6
+  NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2 NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7
+  NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3 NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 VDDCE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VSSE WLA0_0 WLA0_1 WLA0_2 WLA0_3
+  WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13
+  WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22
+  WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31
+  WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9
+  WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18
+  WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27
+  WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5
+  WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1
+  WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11
+  WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20
+  WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29
+  WLB1_30 WLB1_31 RAMTP128X16CORE_COLXL
XCORE_COLR BLA0_0_373 BLA0_1_357 BLA0_2_341 BLA0_3_325 BLA0_4_309 BLA0_5_293
+  BLA0_6_277 BLA0_7_261 BLA1_0_363 BLA1_1_347 BLA1_2_331 BLA1_3_315
+  BLA1_4_299 BLA1_5_283 BLA1_6_267 BLA1_7_251 BLB0_0_369 BLB0_1_353
+  BLB0_2_337 BLB0_3_321 BLB0_4_305 BLB0_5_289 BLB0_6_273 BLB0_7_257
+  BLB1_0_367 BLB1_1_351 BLB1_2_335 BLB1_3_319 BLB1_4_303 BLB1_5_287
+  BLB1_6_271 BLB1_7_255 NBLA0_0_375 NBLA0_1_359 NBLA0_2_343 NBLA0_3_327
+  NBLA0_4_311 NBLA0_5_295 NBLA0_6_279 NBLA0_7_263 NBLA1_0_361 NBLA1_1_345
+  NBLA1_2_329 NBLA1_3_313 NBLA1_4_297 NBLA1_5_281 NBLA1_6_265 NBLA1_7_249
+  NBLB0_0_371 NBLB0_1_355 NBLB0_2_339 NBLB0_3_323 NBLB0_4_307 NBLB0_5_291
+  NBLB0_6_275 NBLB0_7_259 NBLB1_0_365 NBLB1_1_349 NBLB1_2_333 NBLB1_3_317
+  NBLB1_4_301 NBLB1_5_285 NBLB1_6_269 NBLB1_7_253 VDDCE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VSSE WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4
+  WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14
+  WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23
+  WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1
+  WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11
+  WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20
+  WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29
+  WLB1_30 WLB1_31 RAMTP128X16CORE_COLXR
XLEFTBOT_IO BLA0_0 BLA0_1 BLA0_2 BLA0_3 BLA0_4 BLA0_5 BLA0_6 BLA0_7 BLA1_0
+  BLA1_1 BLA1_2 BLA1_3 BLA1_4 BLA1_5 BLA1_6 BLA1_7 BLB0_0 BLB0_1 BLB0_2
+  BLB0_3 BLB0_4 BLB0_5 BLB0_6 BLB0_7 BLB1_0 BLB1_1 BLB1_2 BLB1_3 BLB1_4
+  BLB1_5 BLB1_6 BLB1_7 DFT DFTB DWLA D_7 D_6 D_5 D_4 D_3 D_2 D_1 D_0 NBLA0_0
+  NBLA0_1 NBLA0_2 NBLA0_3 NBLA0_4 NBLA0_5 NBLA0_6 NBLA0_7 NBLA1_0 NBLA1_1
+  NBLA1_2 NBLA1_3 NBLA1_4 NBLA1_5 NBLA1_6 NBLA1_7 NBLB0_0 NBLB0_1 NBLB0_2
+  NBLB0_3 NBLB0_4 NBLB0_5 NBLB0_6 NBLB0_7 NBLB1_0 NBLB1_1 NBLB1_2 NBLB1_3
+  NBLB1_4 NBLB1_5 NBLB1_6 NBLB1_7 NSAE NYPCLK0A NYPCLK1A PRECHA PRECHB Q_7
+  Q_6 Q_5 Q_4 Q_3 Q_2 Q_1 Q_0 SAPRECH SEL_D SEL_SI SEL_TD SI_0 SI_1 TE SI_0
+  TIELO_1 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE_156 VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VDDCE VSSE VSSE WCLK WEN_7
+  WEN_6 WEN_5 WEN_4 WEN_3 WEN_2 WEN_1 WEN_0 YPCLK0B YPCLK1B YPCOLCLK0
+  YPCOLCLK1 RAMTP128X16BOT_IO_LT
XRIGHTBOT_IO BLA0_0_373 BLA0_1_357 BLA0_2_341 BLA0_3_325 BLA0_4_309 BLA0_5_293
+  BLA0_6_277 BLA0_7_261 BLA1_0_363 BLA1_1_347 BLA1_2_331 BLA1_3_315
+  BLA1_4_299 BLA1_5_283 BLA1_6_267 BLA1_7_251 BLB0_0_369 BLB0_1_353
+  BLB0_2_337 BLB0_3_321 BLB0_4_305 BLB0_5_289 BLB0_6_273 BLB0_7_257
+  BLB1_0_367 BLB1_1_351 BLB1_2_335 BLB1_3_319 BLB1_4_303 BLB1_5_287
+  BLB1_6_271 BLB1_7_255 DFT DFTB DWLB D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15
+  NBLA0_0_375 NBLA0_1_359 NBLA0_2_343 NBLA0_3_327 NBLA0_4_311 NBLA0_5_295
+  NBLA0_6_279 NBLA0_7_263 NBLA1_0_361 NBLA1_1_345 NBLA1_2_329 NBLA1_3_313
+  NBLA1_4_297 NBLA1_5_281 NBLA1_6_265 NBLA1_7_249 NBLB0_0_371 NBLB0_1_355
+  NBLB0_2_339 NBLB0_3_323 NBLB0_4_307 NBLB0_5_291 NBLB0_6_275 NBLB0_7_259
+  NBLB1_0_365 NBLB1_1_349 NBLB1_2_333 NBLB1_3_317 NBLB1_4_301 NBLB1_5_285
+  NBLB1_6_269 NBLB1_7_253 NSAE NYPCLK0A NYPCLK1A PRECHA_R PRECHB_R Q_8 Q_9
+  Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 SAPRECH SEL_D SEL_SI SEL_TD TIELOFPB ISIA1 TE
+  TIELOFPB TIELOCDB SI_0 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE_242 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VDDCE VSSE
+  VSSE WCLK WEN_7 WEN_8 WEN_9 WEN_10 WEN_11 WEN_12 WEN_13 WEN_14 WEN_15
+  YPCLK0B YPCLK1B YPCOLCLK0 YPCOLCLK1 RAMTP128X16BOT_IO_RT
XWD_STACKCAP DBLA_OUT DBLB DWLA DWLB EMAA0 EMAA1 EMAA2 EMAB0 EMAB1 EMAB2 GTPA1
+  GTPA1 GTPB0 GTPB0 LAA[0] LAA[1] LAB[0] LAB[1] LOG0_DWLA LOG0_DWLB LOG1A
+  LOG1B RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RETA RETB VDDCE VDDPE VSSE WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4
+  WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14
+  WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23
+  WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0
+  WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10
+  WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19
+  WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28
+  WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6
+  WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15
+  WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24
+  WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1
+  WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11
+  WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20
+  WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29
+  WLB1_30 WLB1_31 RAMTP128X16WD_STACKCAP
.ENDS RAMTP128X16TTOP
****
.SUBCKT RAMTP128X16 VDDCE VDDPE VSSE QA[15] QA[14] QA[13] QA[12] QA[11] QA[10]
+  QA[9] QA[8] QA[7] QA[6] QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] CLKA CENA AA[6]
+  AA[5] AA[4] AA[3] AA[2] AA[1] AA[0] CLKB CENB WENB[15] WENB[14] WENB[13]
+  WENB[12] WENB[11] WENB[10] WENB[9] WENB[8] WENB[7] WENB[6] WENB[5] WENB[4]
+  WENB[3] WENB[2] WENB[1] WENB[0] AB[6] AB[5] AB[4] AB[3] AB[2] AB[1] AB[0]
+  DB[15] DB[14] DB[13] DB[12] DB[11] DB[10] DB[9] DB[8] DB[7] DB[6] DB[5]
+  DB[4] DB[3] DB[2] DB[1] DB[0] EMAA[2] EMAA[1] EMAA[0] EMAB[2] EMAB[1]
+  EMAB[0] RET1N COLLDISN
** RAMTP128X16: 23507 flat devices **
XI0 AA[0] AB[0] CENA CENB CLKA CLKB COLLDISN DB[0] DB[1] DB[2] DB[3] DB[4]
